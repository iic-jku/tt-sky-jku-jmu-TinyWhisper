** sch_path: magic/iq_modulator/tt_um_TinyWhisper_pex_tb_tran.sch
**.subckt tt_um_TinyWhisper_pex_tb_tran
C1 vout_RF GND {Cload} m=1
R1 vout_RF GND {Rload} m=1
VDD VDD GND {VDD}
Vloi LO_I GND pulse(0 {VDD} 0 10p 10p {0.25/flo} {1/flo})
Vloix LO_IX GND pulse(0 {VDD} {0.50/flo} 10p 10p {0.25/flo} {1/flo})
Vloqx LO_QX GND pulse(0 {VDD} {0.75/flo} 10p 10p {0.25/flo} {1/flo})
Vcm Vcm GND {Vcm}
Vloq LO_Q GND pulse(0 {VDD} {0.25/flo} 10p 10p {0.25/flo} {1/flo})
vsine vind_Q GND sin(0 {VDD/2} {fsig})
E4 Vcm vinn_I_cosine net1 GND 0.5
E5 vinp_I_cosine Vcm net1 GND 0.5
E6 net1 GND vind_I GND 1
E2 net3 GND vinp_I_pwm GND -1
Vofs_Q net2 GND {VDD}
E3 vinn_I_pwm net2 net3 GND 1
Vmeas1 vinp_Q_pwm vinp_Q 0
.save i(vmeas1)
Vmeas2 vinn_Q_pwm vinn_Q 0
.save i(vmeas2)
vpwm_cosine_50 vinp_I_pwm GND dc 0 pwl(0.0 1.8 6.138392857142856e-09 1.8 6.696428571428571e-09 0.0
+ 1.1160714285714285e-08 0.0 1.1718749999999999e-08 1.8 2.399553571428571e-08 1.8 2.4553571428571426e-08 0.0
+ 2.9017857142857142e-08 0.0 2.9575892857142856e-08 1.8 4.185267857142857e-08 1.8 4.241071428571428e-08 0.0
+ 4.6874999999999995e-08 0.0 4.743303571428571e-08 1.8 5.970982142857143e-08 1.8 6.026785714285714e-08 0.0
+ 6.473214285714285e-08 0.0 6.529017857142856e-08 1.8 7.756696428571428e-08 1.8 7.812499999999999e-08 0.0
+ 8.25892857142857e-08 0.0 8.314732142857142e-08 1.8 9.542410714285713e-08 1.8 9.598214285714285e-08 0.0
+ 1.0044642857142856e-07 0.0 1.0100446428571428e-07 1.8 1.1328124999999999e-07 1.8 1.1383928571428571e-07 0.0
+ 1.1830357142857142e-07 0.0 1.1886160714285714e-07 1.8 1.3113839285714285e-07 1.8 1.3169642857142855e-07 0.0
+ 1.3616071428571426e-07 0.0 1.3671875e-07 1.8 1.489955357142857e-07 1.8 1.4955357142857143e-07 0.0 1.5401785714285714e-07
+ 0.0 1.5457589285714284e-07 1.8 1.6685267857142856e-07 1.8 1.6741071428571428e-07 0.0 1.71875e-07 0.0
+ 1.724330357142857e-07 1.8 1.847098214285714e-07 1.8 1.8526785714285713e-07 0.0 1.8973214285714285e-07 0.0
+ 1.9029017857142855e-07 1.8 2.0256696428571426e-07 1.8 2.03125e-07 0.0 2.075892857142857e-07 0.0 2.0814732142857142e-07 1.8
+ 2.2042410714285712e-07 1.8 2.2098214285714284e-07 0.0 2.2544642857142855e-07 0.0 2.2600446428571428e-07 1.8 2.3828125e-07
+ 1.8 2.388392857142857e-07 0.0 2.433035714285714e-07 0.0 2.438616071428571e-07 1.8 2.561383928571428e-07
+ 1.8 2.5669642857142857e-07 0.0 2.6116071428571426e-07 0.0 2.6171874999999996e-07 1.8
+ 2.739955357142857e-07 1.8 2.745535714285714e-07 0.0 2.790178571428571e-07 0.0 2.7957589285714286e-07 1.8
+ 2.918526785714285e-07 1.8 2.924107142857143e-07 0.0 2.9687499999999996e-07 0.0 2.974330357142857e-07 1.8
+ 3.0970982142857143e-07 1.8 3.1026785714285713e-07 0.0 3.147321428571428e-07 0.0 3.1529017857142857e-07 1.8
+ 3.275669642857143e-07 1.8 3.28125e-07 0.0 3.3258928571428567e-07 0.0 3.331473214285714e-07 1.8 3.4542410714285714e-07 1.8
+ 3.4598214285714283e-07 0.0 3.504464285714285e-07 0.0 3.5100446428571427e-07 1.8 3.6328125e-07 1.8 3.638392857142857e-07
+ 0.0 3.6830357142857143e-07 0.0 3.688616071428571e-07 1.8 3.8113839285714284e-07 1.8
+ 3.8169642857142854e-07 0.0 3.861607142857143e-07 0.0 3.8671875e-07 1.8 3.989955357142857e-07 1.8 3.995535714285714e-07 0.0
+ 4.0401785714285713e-07 0.0 4.0457589285714283e-07 1.8 4.1685267857142855e-07 1.8 4.1741071428571424e-07 0.0 4.21875e-07
+ 0.0 4.224330357142857e-07 1.8 4.347098214285714e-07 1.8 4.352678571428571e-07 0.0
+ 4.3973214285714284e-07 0.0 4.4029017857142853e-07 1.8 4.5256696428571425e-07 1.8 4.5312499999999995e-07 0.0
+ 4.575892857142857e-07 0.0 4.581473214285714e-07 1.8 4.704241071428571e-07 1.8 4.709821428571428e-07 0.0
+ 4.7544642857142854e-07 0.0 4.7600446428571424e-07 1.8 4.8828125e-07 1.8 4.888392857142857e-07 0.0 4.933035714285714e-07
+ 0.0 4.938616071428571e-07 1.8 5.061383928571429e-07 1.8 5.066964285714286e-07 0.0 5.111607142857142e-07
+ 0.0 5.117187499999999e-07 1.8 5.239955357142857e-07 1.8 5.245535714285714e-07 0.0 5.290178571428571e-07
+ 0.0 5.295758928571428e-07 1.8 5.418526785714286e-07 1.8 5.424107142857143e-07 0.0 5.46875e-07 0.0
+ 5.474330357142856e-07 1.8 5.597098214285714e-07 1.8 5.602678571428571e-07 0.0 5.647321428571428e-07 0.0
+ 5.652901785714285e-07 1.8 5.775669642857143e-07 1.8 5.78125e-07 0.0 5.825892857142857e-07 0.0 5.831473214285714e-07 1.8
+ 5.954241071428571e-07 1.8 5.959821428571428e-07 0.0 6.004464285714285e-07 0.0 6.010044642857142e-07 1.8 6.1328125e-07 1.8
+ 6.138392857142857e-07 0.0 6.183035714285714e-07 0.0 6.188616071428571e-07 1.8 6.311383928571428e-07 1.8
+ 6.316964285714285e-07 0.0 6.361607142857142e-07 0.0 6.367187499999999e-07 1.8 6.489955357142857e-07 1.8
+ 6.495535714285714e-07 0.0 6.540178571428571e-07 0.0 6.545758928571428e-07 1.8 6.668526785714285e-07 1.8
+ 6.674107142857142e-07 0.0 6.718749999999999e-07 0.0 6.724330357142856e-07 1.8 6.847098214285714e-07 1.8
+ 6.852678571428571e-07 0.0 6.897321428571428e-07 0.0 6.902901785714285e-07 1.8 7.025669642857142e-07 1.8
+ 7.031249999999999e-07 0.0 7.075892857142856e-07 0.0 7.081473214285714e-07 1.8 7.204241071428571e-07 1.8
+ 7.209821428571428e-07 0.0 7.254464285714285e-07 0.0 7.260044642857143e-07 1.8 7.382812499999999e-07 1.8
+ 7.388392857142856e-07 0.0 7.433035714285713e-07 0.0 7.438616071428571e-07 1.8 7.561383928571428e-07 1.8
+ 7.566964285714285e-07 0.0 7.611607142857142e-07 0.0 7.6171875e-07 1.8 7.739955357142857e-07 1.8 7.745535714285713e-07 0.0
+ 7.79017857142857e-07 0.0 7.795758928571428e-07 1.8 7.918526785714285e-07 1.8 7.924107142857142e-07 0.0 7.96875e-07 0.0
+ 7.974330357142857e-07 1.8 8.097098214285714e-07 1.8 8.102678571428571e-07 0.0 8.147321428571428e-07 0.0
+ 8.152901785714285e-07 1.8 8.275669642857142e-07 1.8 8.281249999999999e-07 0.0 8.325892857142857e-07 0.0
+ 8.331473214285714e-07 1.8 8.454241071428571e-07 1.8 8.459821428571428e-07 0.0 8.504464285714286e-07 0.0
+ 8.510044642857142e-07 1.8 8.632812499999999e-07 1.8 8.638392857142856e-07 0.0 8.683035714285714e-07 0.0
+ 8.688616071428571e-07 1.8 8.811383928571428e-07 1.8 8.816964285714285e-07 0.0 8.861607142857143e-07 0.0 8.8671875e-07 1.8
+ 8.989955357142856e-07 1.8 8.995535714285713e-07 0.0 9.040178571428571e-07 0.0 9.045758928571428e-07 1.8
+ 9.168526785714285e-07 1.8 9.174107142857142e-07 0.0 9.224330357142857e-07 0.0 9.229910714285714e-07 1.8
+ 9.341517857142856e-07 1.8 9.347098214285713e-07 0.0 9.402901785714285e-07 0.0 9.408482142857142e-07 1.8
+ 9.520089285714285e-07 1.8 9.525669642857142e-07 0.0 9.581473214285714e-07 0.0 9.58705357142857e-07 1.8
+ 9.698660714285714e-07 1.8 9.704241071428571e-07 0.0 9.760044642857141e-07 0.0 9.765625e-07 1.8 9.877232142857142e-07 1.8
+ 9.882812499999999e-07 0.0 9.93861607142857e-07 0.0 9.944196428571428e-07 1.8 1.0055803571428571e-06 1.8
+ 1.0061383928571428e-06 0.0 1.01171875e-06 0.0 1.0122767857142857e-06 1.8 1.0234374999999999e-06 1.8 1.0239955357142856e-06
+ 0.0 1.0295758928571428e-06 0.0 1.0301339285714285e-06 1.8 1.0412946428571428e-06 1.8
+ 1.0418526785714285e-06 0.0 1.0474330357142857e-06 0.0 1.0479910714285714e-06 1.8 1.0591517857142856e-06 1.8
+ 1.0597098214285713e-06 0.0 1.0652901785714285e-06 0.0 1.0658482142857142e-06 1.8 1.0770089285714286e-06 1.8
+ 1.0775669642857143e-06 0.0 1.0831473214285714e-06 0.0 1.0837053571428571e-06 1.8 1.0948660714285713e-06 1.8
+ 1.095424107142857e-06 0.0 1.1010044642857142e-06 0.0 1.1015624999999999e-06 1.8 1.1127232142857143e-06 1.8 1.11328125e-06
+ 0.0 1.1188616071428571e-06 0.0 1.1194196428571428e-06 1.8 1.130580357142857e-06 1.8
+ 1.1311383928571427e-06 0.0 1.1367187499999999e-06 0.0 1.1372767857142856e-06 1.8 1.1484375e-06 1.8 1.1489955357142857e-06
+ 0.0 1.1545758928571428e-06 0.0 1.1551339285714285e-06 1.8 1.1662946428571427e-06 1.8
+ 1.1668526785714284e-06 0.0 1.1724330357142856e-06 0.0 1.1729910714285713e-06 1.8 1.1841517857142857e-06 1.8
+ 1.1847098214285714e-06 0.0 1.1902901785714286e-06 0.0 1.1908482142857143e-06 1.8 1.2020089285714284e-06 1.8
+ 1.2025669642857141e-06 0.0 1.2081473214285713e-06 0.0 1.208705357142857e-06 1.8 1.2198660714285714e-06 1.8
+ 1.220424107142857e-06 0.0 1.2260044642857143e-06 0.0 1.2265625e-06 1.8 1.2377232142857141e-06 1.8 1.2382812499999998e-06
+ 0.0 1.243861607142857e-06 0.0 1.2444196428571427e-06 1.8 1.255580357142857e-06 1.8
+ 1.2561383928571428e-06 0.0 1.26171875e-06 0.0 1.2622767857142857e-06 1.8 1.2734374999999998e-06 1.8 1.2739955357142855e-06
+ 0.0 1.2795758928571427e-06 0.0 1.2801339285714284e-06 1.8 1.2912946428571428e-06 1.8
+ 1.2918526785714285e-06 0.0 1.2974330357142857e-06 0.0 1.2979910714285714e-06 1.8 1.3091517857142855e-06 1.8
+ 1.3097098214285714e-06 0.0 1.3152901785714284e-06 0.0 1.3158482142857141e-06 1.8 1.3270089285714285e-06 1.8
+ 1.3275669642857142e-06 0.0 1.333705357142857e-06 0.0 1.3342633928571428e-06 1.8 1.3443080357142855e-06 1.8
+ 1.3448660714285712e-06 0.0 1.3515624999999998e-06 0.0 1.3521205357142855e-06 1.8 1.3621651785714285e-06 1.8
+ 1.3627232142857142e-06 0.0 1.3694196428571428e-06 0.0 1.3699776785714285e-06 1.8 1.3800223214285712e-06 1.8
+ 1.380580357142857e-06 0.0 1.3872767857142855e-06 0.0 1.3878348214285714e-06 1.8 1.3978794642857142e-06 1.8 1.3984375e-06
+ 0.0 1.4051339285714285e-06 0.0 1.4056919642857142e-06 1.8 1.415736607142857e-06 1.8
+ 1.4162946428571429e-06 0.0 1.4229910714285712e-06 0.0 1.4235491071428571e-06 1.8 1.43359375e-06 1.8 1.4341517857142856e-06
+ 0.0 1.4408482142857142e-06 0.0 1.4414062499999999e-06 1.8 1.4514508928571427e-06 1.8
+ 1.4520089285714286e-06 0.0 1.458705357142857e-06 0.0 1.4592633928571428e-06 1.8 1.4693080357142856e-06 1.8
+ 1.4698660714285713e-06 0.0 1.4765624999999999e-06 0.0 1.4771205357142856e-06 1.8 1.4871651785714286e-06 1.8
+ 1.4877232142857143e-06 0.0 1.4944196428571429e-06 0.0 1.4949776785714285e-06 1.8 1.5050223214285713e-06 1.8
+ 1.505580357142857e-06 0.0 1.5122767857142856e-06 0.0 1.5128348214285713e-06 1.8 1.5228794642857143e-06 1.8 1.5234375e-06
+ 0.0 1.5301339285714286e-06 0.0 1.5306919642857143e-06 1.8 1.540736607142857e-06 1.8
+ 1.5412946428571427e-06 0.0 1.5479910714285713e-06 0.0 1.548549107142857e-06 1.8 1.55859375e-06 1.8 1.5591517857142857e-06
+ 0.0 1.5658482142857143e-06 0.0 1.56640625e-06 1.8 1.5764508928571427e-06 1.8 1.5770089285714284e-06 0.0
+ 1.583705357142857e-06 0.0 1.5842633928571427e-06 1.8 1.5943080357142857e-06 1.8 1.5948660714285714e-06 0.0 1.6015625e-06
+ 0.0 1.6021205357142857e-06 1.8 1.6121651785714284e-06 1.8 1.6127232142857141e-06 0.0
+ 1.6194196428571427e-06 0.0 1.6199776785714284e-06 1.8 1.6300223214285714e-06 1.8 1.630580357142857e-06 0.0
+ 1.6372767857142857e-06 0.0 1.6378348214285714e-06 1.8 1.6478794642857141e-06 1.8 1.6484374999999998e-06 0.0
+ 1.6551339285714284e-06 0.0 1.6556919642857141e-06 1.8 1.665736607142857e-06 1.8 1.6662946428571428e-06 0.0
+ 1.6729910714285714e-06 0.0 1.673549107142857e-06 1.8 1.6830357142857141e-06 1.8 1.6835937499999998e-06 0.0
+ 1.6914062499999998e-06 0.0 1.6919642857142855e-06 1.8 1.700892857142857e-06 1.8 1.7014508928571428e-06 0.0
+ 1.7092633928571428e-06 0.0 1.7098214285714285e-06 1.8 1.7187499999999998e-06 1.8 1.7193080357142855e-06 0.0
+ 1.7271205357142855e-06 0.0 1.7276785714285712e-06 1.8 1.7366071428571428e-06 1.8 1.7371651785714285e-06 0.0
+ 1.7449776785714285e-06 0.0 1.7455357142857142e-06 1.8 1.7544642857142856e-06 1.8 1.7550223214285713e-06 0.0
+ 1.7628348214285712e-06 0.0 1.763392857142857e-06 1.8 1.7723214285714285e-06 1.8 1.7728794642857142e-06 0.0
+ 1.7806919642857142e-06 0.0 1.7812499999999999e-06 1.8 1.7901785714285713e-06 1.8 1.790736607142857e-06 0.0
+ 1.798549107142857e-06 0.0 1.7991071428571426e-06 1.8 1.8080357142857142e-06 1.8 1.80859375e-06 0.0 1.8164062499999999e-06
+ 0.0 1.8169642857142856e-06 1.8 1.825892857142857e-06 1.8 1.8264508928571427e-06 0.0
+ 1.8342633928571426e-06 0.0 1.8348214285714283e-06 1.8 1.84375e-06 1.8 1.8443080357142856e-06 0.0 1.8521205357142856e-06
+ 0.0 1.8526785714285713e-06 1.8 1.8616071428571427e-06 1.8 1.8621651785714284e-06 0.0
+ 1.8699776785714283e-06 0.0 1.8705357142857143e-06 1.8 1.8794642857142856e-06 1.8 1.8800223214285713e-06 0.0
+ 1.8878348214285713e-06 0.0 1.888392857142857e-06 1.8 1.8973214285714284e-06 1.8 1.897879464285714e-06 0.0
+ 1.905691964285714e-06 0.0 1.90625e-06 1.8 1.9151785714285713e-06 1.8 1.915736607142857e-06 0.0 1.923549107142857e-06 0.0
+ 1.924107142857143e-06 1.8 1.933035714285714e-06 1.8 1.93359375e-06 0.0 1.9414062499999998e-06 0.0 1.9419642857142857e-06
+ 1.8 1.950892857142857e-06 1.8 1.9514508928571427e-06 0.0 1.959263392857143e-06 0.0
+ 1.9598214285714284e-06 1.8 1.96875e-06 1.8 1.9693080357142855e-06 0.0 1.9771205357142857e-06 0.0 1.977678571428571e-06 1.8
+ 1.9866071428571427e-06 1.8 1.9871651785714282e-06 0.0 1.9949776785714284e-06 0.0 1.9955357142857143e-06 1.8 2.00390625e-06
+ 1.8 2.0044642857142855e-06 0.0 2.013392857142857e-06 0.0 2.0139508928571426e-06 1.8
+ 2.0217633928571428e-06 1.8 2.0223214285714282e-06 0.0 2.03125e-06 0.0 2.0318080357142857e-06 1.8 2.0396205357142855e-06
+ 1.8 2.0401785714285714e-06 0.0 2.0491071428571426e-06 0.0 2.0496651785714285e-06 1.8
+ 2.0574776785714282e-06 1.8 2.058035714285714e-06 0.0 2.0669642857142857e-06 0.0 2.0675223214285712e-06 1.8
+ 2.0753348214285714e-06 1.8 2.075892857142857e-06 0.0 2.0848214285714285e-06 0.0 2.085379464285714e-06 1.8
+ 2.093191964285714e-06 1.8 2.0937499999999996e-06 0.0 2.1026785714285712e-06 0.0 2.103236607142857e-06 1.8
+ 2.111049107142857e-06 1.8 2.111607142857143e-06 0.0 2.120535714285714e-06 0.0 2.12109375e-06 1.8 2.1289062499999997e-06
+ 1.8 2.1294642857142856e-06 0.0 2.138392857142857e-06 0.0 2.1389508928571426e-06 1.8
+ 2.146763392857143e-06 1.8 2.1473214285714283e-06 0.0 2.15625e-06 0.0 2.1568080357142854e-06 1.8 2.1646205357142856e-06
+ 1.8 2.1651785714285715e-06 0.0 2.1741071428571426e-06 0.0 2.1746651785714286e-06 1.8
+ 2.1824776785714283e-06 1.8 2.1830357142857142e-06 0.0 2.1919642857142854e-06 0.0 2.1925223214285713e-06 1.8
+ 2.200334821428571e-06 1.8 2.200892857142857e-06 0.0 2.2098214285714286e-06 0.0 2.210379464285714e-06 1.8
+ 2.2181919642857142e-06 1.8 2.2187499999999997e-06 0.0 2.2276785714285713e-06 0.0 2.228236607142857e-06 1.8
+ 2.236049107142857e-06 1.8 2.236607142857143e-06 0.0 2.245535714285714e-06 0.0 2.24609375e-06 1.8 2.2539062499999997e-06
+ 1.8 2.2544642857142856e-06 0.0 2.263392857142857e-06 0.0 2.2639508928571427e-06 1.8
+ 2.271763392857143e-06 1.8 2.2723214285714284e-06 0.0 2.28125e-06 0.0 2.2818080357142855e-06 1.8 2.2896205357142856e-06
+ 1.8 2.290178571428571e-06 0.0 2.2991071428571427e-06 0.0 2.299665178571428e-06 1.8
+ 2.3074776785714284e-06 1.8 2.3080357142857143e-06 0.0 2.3169642857142855e-06 0.0 2.3175223214285714e-06 1.8
+ 2.3247767857142857e-06 1.8 2.325334821428571e-06 0.0 2.335379464285714e-06 0.0 2.3359375e-06 1.8 2.3426339285714284e-06
+ 1.8 2.3431919642857143e-06 0.0 2.353236607142857e-06 0.0 2.3537946428571428e-06 1.8
+ 2.360491071428571e-06 1.8 2.361049107142857e-06 0.0 2.37109375e-06 0.0 2.3716517857142855e-06 1.8 2.3783482142857143e-06
+ 1.8 2.37890625e-06 0.0 2.3889508928571428e-06 0.0 2.3895089285714283e-06 1.8 2.396205357142857e-06 1.8
+ 2.3967633928571425e-06 0.0 2.4068080357142855e-06 0.0 2.4073660714285714e-06 1.8 2.4140625e-06 1.8 2.4146205357142857e-06
+ 0.0 2.4246651785714283e-06 0.0 2.425223214285714e-06 1.8 2.4319196428571426e-06 1.8
+ 2.4324776785714285e-06 0.0 2.4425223214285714e-06 0.0 2.443080357142857e-06 1.8 2.4497767857142857e-06 1.8
+ 2.4503348214285712e-06 0.0 2.460379464285714e-06 0.0 2.4609374999999997e-06 1.8 2.4676339285714285e-06 1.8
+ 2.468191964285714e-06 0.0 2.478236607142857e-06 0.0 2.478794642857143e-06 1.8 2.4854910714285712e-06 1.8
+ 2.486049107142857e-06 0.0 2.4960937499999997e-06 0.0 2.4966517857142856e-06 1.8 2.503348214285714e-06 1.8 2.50390625e-06
+ 0.0 2.513950892857143e-06 0.0 2.5145089285714283e-06 1.8 2.521205357142857e-06 1.8
+ 2.5217633928571426e-06 0.0 2.5318080357142856e-06 0.0 2.532366071428571e-06 1.8 2.5390625e-06 1.8 2.5396205357142854e-06
+ 0.0 2.5496651785714283e-06 0.0 2.5502232142857143e-06 1.8 2.5569196428571426e-06 1.8
+ 2.5574776785714285e-06 0.0 2.567522321428571e-06 0.0 2.568080357142857e-06 1.8 2.5747767857142854e-06 1.8
+ 2.5753348214285713e-06 0.0 2.5853794642857143e-06 0.0 2.5859374999999998e-06 1.8 2.5926339285714285e-06 1.8
+ 2.593191964285714e-06 0.0 2.603236607142857e-06 0.0 2.6037946428571425e-06 1.8 2.6104910714285713e-06 1.8
+ 2.6110491071428568e-06 0.0 2.6210937499999998e-06 0.0 2.6216517857142857e-06 1.8 2.628348214285714e-06 1.8 2.62890625e-06
+ 0.0 2.6389508928571425e-06 0.0 2.6395089285714284e-06 1.8 2.6462053571428568e-06 1.8
+ 2.6467633928571427e-06 0.0 2.6568080357142857e-06 0.0 2.657366071428571e-06 1.8 2.6640625e-06 1.8 2.6646205357142854e-06
+ 0.0 2.675223214285714e-06 0.0 2.67578125e-06 1.8 2.681361607142857e-06 1.8 2.6819196428571427e-06 0.0
+ 2.693080357142857e-06 0.0 2.6936383928571426e-06 1.8 2.69921875e-06 1.8 2.6997767857142855e-06 0.0 2.7109375e-06 0.0
+ 2.7114955357142853e-06 1.8 2.7170758928571427e-06 1.8 2.717633928571428e-06 0.0 2.7287946428571426e-06 0.0
+ 2.7293526785714285e-06 1.8 2.7349330357142855e-06 1.8 2.7354910714285714e-06 0.0 2.7466517857142853e-06 0.0
+ 2.7472098214285712e-06 1.8 2.752790178571428e-06 1.8 2.753348214285714e-06 0.0 2.7645089285714285e-06 0.0
+ 2.765066964285714e-06 1.8 2.7706473214285714e-06 1.8 2.771205357142857e-06 0.0 2.7823660714285712e-06 0.0
+ 2.782924107142857e-06 1.8 2.788504464285714e-06 1.8 2.7890624999999996e-06 0.0 2.800223214285714e-06 0.0 2.80078125e-06
+ 1.8 2.806361607142857e-06 1.8 2.8069196428571428e-06 0.0 2.8180803571428567e-06 0.0
+ 2.8186383928571426e-06 1.8 2.8242187499999996e-06 1.8 2.8247767857142855e-06 0.0 2.8359375e-06 0.0 2.8364955357142854e-06
+ 1.8 2.8420758928571428e-06 1.8 2.8426339285714283e-06 0.0 2.8537946428571426e-06 0.0
+ 2.8543526785714286e-06 1.8 2.8599330357142855e-06 1.8 2.860491071428571e-06 0.0 2.8716517857142854e-06 0.0
+ 2.8722098214285713e-06 1.8 2.8777901785714283e-06 1.8 2.878348214285714e-06 0.0 2.8895089285714286e-06 0.0
+ 2.890066964285714e-06 1.8 2.895647321428571e-06 1.8 2.896205357142857e-06 0.0 2.9073660714285713e-06 0.0
+ 2.907924107142857e-06 1.8 2.913504464285714e-06 1.8 2.9140624999999997e-06 0.0 2.925223214285714e-06 0.0 2.92578125e-06
+ 1.8 2.931361607142857e-06 1.8 2.931919642857143e-06 0.0 2.943080357142857e-06 0.0
+ 2.9436383928571427e-06 1.8 2.9492187499999997e-06 1.8 2.9497767857142856e-06 0.0 2.9609375e-06 0.0 2.9614955357142855e-06
+ 1.8 2.9670758928571424e-06 1.8 2.9676339285714283e-06 0.0 2.9787946428571427e-06 0.0
+ 2.979352678571428e-06 1.8 2.9849330357142856e-06 1.8 2.985491071428571e-06 0.0 2.9966517857142855e-06 0.0
+ 2.9972098214285714e-06 1.8 3.0027901785714284e-06 1.8 3.0033482142857143e-06 0.0 3.0145089285714282e-06 0.0
+ 3.015066964285714e-06 1.8 3.020647321428571e-06 1.8 3.021205357142857e-06 0.0 3.0323660714285714e-06 0.0
+ 3.032924107142857e-06 1.8 3.0385044642857143e-06 1.8 3.0390624999999998e-06 0.0 3.050223214285714e-06 0.0
+ 3.0507812499999996e-06 1.8 3.056361607142857e-06 1.8 3.0569196428571425e-06 0.0 3.068080357142857e-06 0.0
+ 3.0686383928571428e-06 1.8 3.0742187499999998e-06 1.8 3.0747767857142857e-06 0.0 3.0864955357142855e-06 0.0
+ 3.087053571428571e-06 1.8 3.091517857142857e-06 1.8 3.0920758928571425e-06 0.0 3.1043526785714283e-06 0.0
+ 3.104910714285714e-06 1.8 3.1093749999999998e-06 1.8 3.1099330357142857e-06 0.0 3.122209821428571e-06 0.0
+ 3.122767857142857e-06 1.8 3.1272321428571425e-06 1.8 3.1277901785714284e-06 0.0 3.140066964285714e-06 0.0
+ 3.1406249999999997e-06 1.8 3.1450892857142857e-06 1.8 3.145647321428571e-06 0.0 3.157924107142857e-06 0.0
+ 3.1584821428571424e-06 1.8 3.1629464285714284e-06 1.8 3.163504464285714e-06 0.0 3.1757812499999997e-06 0.0
+ 3.1763392857142856e-06 1.8 3.180803571428571e-06 1.8 3.181361607142857e-06 0.0 3.1936383928571424e-06 0.0
+ 3.1941964285714283e-06 1.8 3.198660714285714e-06 1.8 3.19921875e-06 0.0 3.2114955357142856e-06 0.0 3.212053571428571e-06
+ 1.8 3.216517857142857e-06 1.8 3.2170758928571426e-06 0.0 3.2293526785714284e-06 0.0
+ 3.2299107142857143e-06 1.8 3.234375e-06 1.8 3.2349330357142853e-06 0.0 3.247209821428571e-06 0.0 3.247767857142857e-06 1.8
+ 3.2522321428571426e-06 1.8 3.2527901785714285e-06 0.0 3.265066964285714e-06 0.0 3.2656249999999998e-06 1.8
+ 3.2700892857142853e-06 1.8 3.2706473214285712e-06 0.0 3.282924107142857e-06 0.0 3.2834821428571425e-06 1.8
+ 3.2879464285714285e-06 1.8 3.288504464285714e-06 0.0 3.3007812499999998e-06 0.0 3.3013392857142857e-06 1.8
+ 3.3058035714285713e-06 1.8 3.3063616071428567e-06 0.0 3.3186383928571425e-06 0.0 3.3191964285714284e-06 1.8
+ 3.323660714285714e-06 1.8 3.32421875e-06 0.0 3.3364955357142857e-06 0.0 3.337053571428571e-06 1.8 3.3415178571428567e-06
+ 1.8 3.3420758928571427e-06 0.0 3.3543526785714284e-06 0.0 3.354910714285714e-06 1.8 3.359375e-06 1.8
+ 3.3599330357142854e-06 0.0 3.372209821428571e-06 0.0 3.372767857142857e-06 1.8 3.3772321428571427e-06 1.8
+ 3.377790178571428e-06 0.0 3.390066964285714e-06 0.0 3.390625e-06 1.8 3.3950892857142854e-06 1.8 3.3956473214285713e-06
+ 0.0 3.407924107142857e-06 0.0 3.4084821428571426e-06 1.8 3.412946428571428e-06 1.8
+ 3.413504464285714e-06 0.0 3.42578125e-06 0.0 3.4263392857142853e-06 1.8 3.4308035714285713e-06 1.8 3.431361607142857e-06
+ 0.0 3.4436383928571426e-06 0.0 3.4441964285714285e-06 1.8 3.448660714285714e-06 1.8
+ 3.4492187499999996e-06 0.0 3.4614955357142853e-06 0.0 3.4620535714285712e-06 1.8 3.466517857142857e-06 1.8
+ 3.4670758928571427e-06 0.0 3.4793526785714285e-06 0.0 3.479910714285714e-06 1.8 3.4843749999999996e-06 1.8
+ 3.4849330357142855e-06 0.0 3.4972098214285712e-06 0.0 3.4977678571428567e-06 1.8 3.5022321428571427e-06 1.8
+ 3.5027901785714282e-06 0.0 3.515066964285714e-06 0.0 3.515625e-06 1.8 3.5200892857142855e-06 1.8 3.520647321428571e-06 0.0
+ 3.5329241071428567e-06 0.0 3.5334821428571427e-06 1.8 3.5379464285714282e-06 1.8 3.538504464285714e-06 0.0 3.55078125e-06
+ 0.0 3.5513392857142854e-06 1.8 3.555803571428571e-06 1.8 3.556361607142857e-06 0.0
+ 3.5686383928571427e-06 0.0 3.569196428571428e-06 1.8 3.573660714285714e-06 1.8 3.5742187499999996e-06 0.0
+ 3.5864955357142854e-06 0.0 3.5870535714285713e-06 1.8 3.591517857142857e-06 1.8 3.592075892857143e-06 0.0
+ 3.604352678571428e-06 0.0 3.604910714285714e-06 1.8 3.6093749999999996e-06 1.8 3.6099330357142856e-06 0.0
+ 3.6222098214285713e-06 0.0 3.622767857142857e-06 1.8 3.6272321428571424e-06 1.8 3.6277901785714283e-06 0.0
+ 3.640066964285714e-06 0.0 3.6406249999999996e-06 1.8 3.6450892857142856e-06 1.8 3.645647321428571e-06 0.0
+ 3.657924107142857e-06 0.0 3.6584821428571427e-06 1.8 3.6629464285714283e-06 1.8 3.6635044642857142e-06 0.0
+ 3.6757812499999996e-06 0.0 3.6763392857142855e-06 1.8 3.680803571428571e-06 1.8 3.681361607142857e-06 0.0
+ 3.6936383928571427e-06 0.0 3.6941964285714282e-06 1.8 3.6986607142857142e-06 1.8 3.6992187499999997e-06 0.0
+ 3.7114955357142855e-06 0.0 3.712053571428571e-06 1.8 3.716517857142857e-06 1.8 3.7170758928571425e-06 0.0
+ 3.7293526785714282e-06 0.0 3.729910714285714e-06 1.8 3.7343749999999997e-06 1.8 3.7349330357142856e-06 0.0
+ 3.747209821428571e-06 0.0 3.747767857142857e-06 1.8 3.7522321428571425e-06 1.8 3.7527901785714284e-06 0.0
+ 3.765066964285714e-06 0.0 3.7656249999999996e-06 1.8 3.7700892857142856e-06 1.8 3.770647321428571e-06 0.0
+ 3.782924107142857e-06 0.0 3.7834821428571424e-06 1.8 3.7879464285714284e-06 1.8 3.788504464285714e-06 0.0
+ 3.8007812499999996e-06 0.0 3.8013392857142855e-06 1.8 3.805803571428571e-06 1.8 3.806361607142857e-06 0.0
+ 3.818638392857143e-06 0.0 3.819196428571429e-06 1.8 3.823660714285714e-06 1.8 3.824218749999999e-06 0.0
+ 3.836495535714285e-06 0.0 3.837053571428571e-06 1.8 3.841517857142857e-06 1.8 3.8420758928571425e-06 0.0
+ 3.854352678571428e-06 0.0 3.854910714285714e-06 1.8 3.859375e-06 1.8 3.859933035714286e-06 0.0 3.8722098214285715e-06 0.0
+ 3.8727678571428565e-06 1.8 3.877232142857143e-06 1.8 3.877790178571428e-06 0.0 3.890066964285714e-06 0.0 3.890625e-06 1.8
+ 3.895089285714285e-06 1.8 3.895647321428571e-06 0.0 3.907924107142857e-06 0.0 3.908482142857143e-06 1.8
+ 3.9129464285714285e-06 1.8 3.913504464285714e-06 0.0 3.92578125e-06 0.0 3.926339285714285e-06 1.8 3.930803571428571e-06
+ 1.8 3.931361607142857e-06 0.0 3.9436383928571425e-06 0.0 3.944196428571428e-06 1.8
+ 3.948660714285714e-06 1.8 3.94921875e-06 0.0 3.961495535714286e-06 0.0 3.9620535714285715e-06 1.8 3.966517857142857e-06
+ 1.8 3.967075892857142e-06 0.0 3.979352678571428e-06 0.0 3.979910714285714e-06 1.8
+ 3.9843749999999994e-06 1.8 3.984933035714285e-06 0.0 3.997209821428571e-06 0.0 3.997767857142857e-06 1.8
+ 4.002232142857143e-06 1.8 4.0027901785714285e-06 0.0 4.015066964285714e-06 0.0 4.015624999999999e-06 1.8
+ 4.020089285714286e-06 1.8 4.020647321428571e-06 0.0 4.032924107142857e-06 0.0 4.0334821428571425e-06 1.8
+ 4.037946428571428e-06 1.8 4.038504464285714e-06 0.0 4.05078125e-06 0.0 4.051339285714286e-06 1.8 4.055803571428571e-06
+ 1.8 4.056361607142857e-06 0.0 4.068638392857143e-06 0.0 4.069196428571428e-06 1.8 4.073660714285714e-06
+ 1.8 4.0742187499999995e-06 0.0 4.086495535714285e-06 0.0 4.087053571428571e-06 1.8
+ 4.091517857142857e-06 1.8 4.092075892857143e-06 0.0 4.1043526785714284e-06 0.0 4.104910714285714e-06 1.8 4.109375e-06 1.8
+ 4.109933035714285e-06 0.0 4.122209821428571e-06 0.0 4.122767857142857e-06 1.8 4.127232142857142e-06 1.8
+ 4.127790178571428e-06 0.0 4.140066964285714e-06 0.0 4.140625e-06 1.8 4.1450892857142854e-06 1.8 4.145647321428571e-06 0.0
+ 4.157924107142857e-06 0.0 4.158482142857142e-06 1.8 4.162946428571429e-06 1.8 4.163504464285714e-06 0.0
+ 4.1757812499999994e-06 0.0 4.176339285714285e-06 1.8 4.180803571428571e-06 1.8 4.181361607142857e-06 0.0
+ 4.193638392857143e-06 0.0 4.1941964285714285e-06 1.8 4.198660714285714e-06 1.8 4.19921875e-06 0.0 4.211495535714286e-06
+ 0.0 4.212053571428571e-06 1.8 4.216517857142857e-06 1.8 4.217075892857142e-06 0.0 4.229352678571428e-06
+ 0.0 4.229910714285714e-06 1.8 4.234375e-06 1.8 4.2349330357142855e-06 0.0 4.247209821428571e-06 0.0
+ 4.247767857142857e-06 1.8 4.252232142857143e-06 1.8 4.252790178571429e-06 0.0 4.265066964285714e-06 0.0
+ 4.2656249999999995e-06 1.8 4.270089285714285e-06 1.8 4.270647321428571e-06 0.0 4.282924107142857e-06 0.0
+ 4.283482142857143e-06 1.8 4.287946428571428e-06 1.8 4.288504464285714e-06 0.0 4.30078125e-06 0.0 4.301339285714285e-06
+ 1.8 4.305803571428571e-06 1.8 4.3063616071428565e-06 0.0 4.318638392857142e-06 0.0
+ 4.319196428571428e-06 1.8 4.323660714285714e-06 1.8 4.32421875e-06 0.0 4.3364955357142854e-06 0.0 4.337053571428571e-06
+ 1.8 4.341517857142857e-06 1.8 4.342075892857143e-06 0.0 4.354352678571429e-06 0.0 4.354910714285714e-06
+ 1.8 4.359375e-06 1.8 4.359933035714285e-06 0.0 4.372209821428571e-06 0.0 4.372767857142857e-06 1.8
+ 4.377232142857142e-06 1.8 4.377790178571428e-06 0.0 4.390066964285714e-06 0.0 4.390625e-06 1.8 4.395089285714286e-06 1.8
+ 4.3956473214285715e-06 0.0 4.407924107142856e-06 0.0 4.408482142857142e-06 1.8 4.412946428571428e-06 1.8
+ 4.413504464285714e-06 0.0 4.42578125e-06 0.0 4.4263392857142855e-06 1.8 4.430803571428571e-06 1.8 4.431361607142857e-06
+ 0.0 4.443638392857143e-06 0.0 4.444196428571429e-06 1.8 4.448660714285714e-06 1.8 4.449218749999999e-06
+ 0.0 4.461495535714285e-06 0.0 4.462053571428571e-06 1.8 4.4665178571428566e-06 1.8
+ 4.4670758928571425e-06 0.0 4.479352678571428e-06 0.0 4.479910714285714e-06 1.8 4.484375e-06 1.8 4.484933035714286e-06 0.0
+ 4.497209821428571e-06 0.0 4.4977678571428565e-06 1.8 4.502232142857143e-06 1.8 4.502790178571428e-06 0.0
+ 4.515066964285714e-06 0.0 4.515625e-06 1.8 4.520089285714285e-06 1.8 4.520647321428571e-06 0.0 4.532924107142857e-06 0.0
+ 4.533482142857143e-06 1.8 4.537946428571428e-06 1.8 4.538504464285714e-06 0.0 4.55078125e-06 0.0 4.551339285714285e-06
+ 1.8 4.555803571428571e-06 1.8 4.556361607142857e-06 0.0 4.568638392857142e-06 0.0 4.569196428571428e-06
+ 1.8 4.573660714285714e-06 1.8 4.57421875e-06 0.0 4.5864955357142856e-06 0.0 4.5870535714285715e-06 1.8
+ 4.591517857142857e-06 1.8 4.592075892857142e-06 0.0 4.604352678571428e-06 0.0 4.604910714285714e-06 1.8
+ 4.609374999999999e-06 1.8 4.609933035714285e-06 0.0 4.622209821428571e-06 0.0 4.622767857142857e-06 1.8
+ 4.6272321428571426e-06 1.8 4.6277901785714285e-06 0.0 4.640066964285714e-06 0.0 4.640624999999999e-06 1.8
+ 4.645089285714286e-06 1.8 4.645647321428571e-06 0.0 4.6579241071428566e-06 0.0 4.6584821428571425e-06 1.8
+ 4.662946428571428e-06 1.8 4.663504464285714e-06 0.0 4.67578125e-06 0.0 4.676339285714286e-06 1.8 4.680803571428571e-06
+ 1.8 4.681361607142857e-06 0.0 4.693638392857143e-06 0.0 4.694196428571428e-06 1.8
+ 4.6986607142857135e-06 1.8 4.6992187499999995e-06 0.0 4.711495535714285e-06 0.0 4.712053571428571e-06 1.8
+ 4.716517857142857e-06 1.8 4.717075892857143e-06 0.0 4.729352678571428e-06 0.0 4.729910714285714e-06 1.8 4.734375e-06 1.8
+ 4.734933035714286e-06 0.0 4.747209821428571e-06 0.0 4.747767857142857e-06 1.8 4.752232142857142e-06 1.8
+ 4.752790178571428e-06 0.0 4.765066964285714e-06 0.0 4.765625e-06 1.8 4.770089285714285e-06 1.8 4.770647321428571e-06 0.0
+ 4.782924107142857e-06 0.0 4.783482142857142e-06 1.8 4.7879464285714285e-06 1.8 4.788504464285714e-06 0.0
+ 4.800781249999999e-06 0.0 4.801339285714285e-06 1.8 4.805803571428571e-06 1.8 4.806361607142857e-06 0.0
+ 4.8186383928571425e-06 0.0 4.8191964285714285e-06 1.8 4.823660714285714e-06 1.8 4.82421875e-06 0.0 4.836495535714286e-06
+ 0.0 4.837053571428571e-06 1.8 4.841517857142857e-06 1.8 4.842075892857142e-06 0.0 4.854352678571428e-06
+ 0.0 4.854910714285714e-06 1.8 4.8593749999999995e-06 1.8 4.8599330357142854e-06 0.0
+ 4.872209821428571e-06 0.0 4.872767857142857e-06 1.8 4.877232142857143e-06 1.8 4.877790178571429e-06 0.0
+ 4.8900669642857135e-06 0.0 4.8906249999999994e-06 1.8 4.895089285714285e-06 1.8 4.895647321428571e-06 0.0
+ 4.907924107142857e-06 0.0 4.908482142857143e-06 1.8 4.912946428571428e-06 1.8 4.913504464285714e-06 0.0
+ 4.925223214285714e-06 0.0 4.92578125e-06 1.8 4.9313616071428564e-06 1.8 4.931919642857142e-06 0.0 4.943080357142857e-06
+ 0.0 4.943638392857142e-06 1.8 4.94921875e-06 1.8 4.9497767857142855e-06 0.0 4.9609374999999995e-06 0.0
+ 4.961495535714285e-06 1.8 4.967075892857143e-06 1.8 4.967633928571428e-06 0.0 4.978794642857143e-06 0.0
+ 4.9793526785714285e-06 1.8 4.984933035714285e-06 1.8 4.985491071428571e-06 0.0 4.996651785714285e-06 0.0
+ 4.997209821428571e-06 1.8 5.002790178571428e-06 1.8 5.003348214285714e-06 0.0 5.014508928571428e-06 0.0
+ 5.015066964285714e-06 1.8 5.0206473214285714e-06 1.8 5.0212053571428565e-06 0.0 5.032366071428571e-06 0.0
+ 5.032924107142857e-06 1.8 5.038504464285714e-06 1.8 5.0390625e-06 0.0 5.050223214285714e-06 0.0 5.0507812499999995e-06
+ 1.8 5.056361607142857e-06 1.8 5.056919642857143e-06 0.0 5.068080357142857e-06 0.0 5.068638392857143e-06
+ 1.8 5.074218749999999e-06 1.8 5.074776785714285e-06 0.0 5.0859375e-06 0.0 5.086495535714285e-06 1.8
+ 5.092075892857142e-06 1.8 5.092633928571428e-06 0.0 5.103794642857142e-06 0.0 5.104352678571428e-06 1.8
+ 5.109933035714286e-06 1.8 5.110491071428571e-06 0.0 5.1216517857142855e-06 0.0 5.122209821428571e-06 1.8
+ 5.127790178571428e-06 1.8 5.128348214285714e-06 0.0 5.139508928571429e-06 0.0 5.140066964285714e-06 1.8
+ 5.145647321428571e-06 1.8 5.146205357142857e-06 0.0 5.157366071428571e-06 0.0 5.157924107142857e-06 1.8
+ 5.163504464285714e-06 1.8 5.164062499999999e-06 0.0 5.175223214285714e-06 0.0 5.17578125e-06 1.8 5.1813616071428566e-06
+ 1.8 5.1819196428571425e-06 0.0 5.1930803571428564e-06 0.0 5.193638392857142e-06 1.8 5.19921875e-06 1.8
+ 5.199776785714286e-06 0.0 5.2109375e-06 0.0 5.2114955357142855e-06 1.8 5.217075892857142e-06 1.8 5.217633928571428e-06
+ 0.0 5.228794642857143e-06 0.0 5.229352678571428e-06 1.8 5.234933035714285e-06 1.8 5.235491071428571e-06
+ 0.0 5.246651785714285e-06 0.0 5.247209821428571e-06 1.8 5.252790178571428e-06 1.8 5.253348214285714e-06
+ 0.0 5.264508928571428e-06 0.0 5.265066964285714e-06 1.8 5.270647321428571e-06 1.8 5.271205357142857e-06
+ 0.0 5.2823660714285714e-06 0.0 5.2829241071428565e-06 1.8 5.288504464285714e-06 1.8 5.2890625e-06 0.0
+ 5.300223214285714e-06 0.0 5.30078125e-06 1.8 5.306361607142857e-06 1.8 5.306919642857142e-06 0.0 5.318080357142857e-06
+ 0.0 5.318638392857143e-06 1.8 5.324218749999999e-06 1.8 5.324776785714285e-06 0.0 5.335379464285714e-06
+ 0.0 5.335937499999999e-06 1.8 5.3426339285714285e-06 1.8 5.3431919642857135e-06 0.0
+ 5.3532366071428565e-06 0.0 5.3537946428571424e-06 1.8 5.360491071428571e-06 1.8 5.361049107142857e-06 0.0 5.37109375e-06
+ 0.0 5.371651785714286e-06 1.8 5.378348214285714e-06 1.8 5.37890625e-06 0.0 5.388950892857143e-06 0.0
+ 5.389508928571428e-06 1.8 5.396205357142857e-06 1.8 5.396763392857142e-06 0.0 5.406808035714285e-06 0.0
+ 5.407366071428571e-06 1.8 5.4140624999999995e-06 1.8 5.414620535714285e-06 0.0 5.424665178571428e-06 0.0
+ 5.425223214285714e-06 1.8 5.431919642857143e-06 1.8 5.4324776785714285e-06 0.0 5.442522321428571e-06 0.0
+ 5.443080357142857e-06 1.8 5.449776785714285e-06 1.8 5.450334821428571e-06 0.0 5.460379464285714e-06 0.0 5.4609375e-06 1.8
+ 5.467633928571428e-06 1.8 5.468191964285714e-06 0.0 5.478236607142857e-06 0.0 5.478794642857142e-06 1.8
+ 5.485491071428571e-06 1.8 5.486049107142856e-06 0.0 5.496093749999999e-06 0.0 5.496651785714285e-06 1.8
+ 5.503348214285714e-06 1.8 5.5039062499999995e-06 0.0 5.5139508928571425e-06 0.0 5.514508928571428e-06 1.8
+ 5.521205357142857e-06 1.8 5.521763392857143e-06 0.0 5.531808035714286e-06 0.0 5.532366071428571e-06 1.8 5.5390625e-06 1.8
+ 5.539620535714285e-06 0.0 5.549665178571428e-06 0.0 5.550223214285714e-06 1.8 5.556919642857142e-06 1.8
+ 5.557477678571428e-06 0.0 5.567522321428571e-06 0.0 5.568080357142857e-06 1.8 5.5747767857142855e-06 1.8
+ 5.575334821428571e-06 0.0 5.5853794642857135e-06 0.0 5.585937499999999e-06 1.8 5.592633928571428e-06 1.8
+ 5.593191964285714e-06 0.0 5.603236607142857e-06 0.0 5.6037946428571426e-06 1.8 5.610491071428571e-06 1.8
+ 5.611049107142857e-06 0.0 5.62109375e-06 0.0 5.621651785714285e-06 1.8 5.628348214285714e-06 1.8 5.628906249999999e-06
+ 0.0 5.638950892857142e-06 0.0 5.639508928571428e-06 1.8 5.6462053571428564e-06 1.8
+ 5.646763392857142e-06 0.0 5.656808035714285e-06 0.0 5.657366071428571e-06 1.8 5.6640625e-06 1.8 5.6646205357142855e-06
+ 0.0 5.6746651785714285e-06 0.0 5.6752232142857136e-06 1.8 5.682477678571428e-06 1.8
+ 5.683035714285714e-06 0.0 5.691964285714285e-06 0.0 5.692522321428571e-06 1.8 5.700334821428571e-06 1.8
+ 5.700892857142857e-06 0.0 5.709821428571428e-06 0.0 5.710379464285714e-06 1.8 5.718191964285714e-06 1.8
+ 5.718749999999999e-06 0.0 5.727678571428571e-06 0.0 5.728236607142856e-06 1.8 5.7360491071428565e-06 1.8
+ 5.736607142857142e-06 0.0 5.745535714285714e-06 0.0 5.7460937499999995e-06 1.8 5.75390625e-06 1.8 5.754464285714286e-06
+ 0.0 5.763392857142857e-06 0.0 5.763950892857143e-06 1.8 5.771763392857143e-06 1.8 5.772321428571428e-06
+ 0.0 5.78125e-06 0.0 5.781808035714285e-06 1.8 5.789620535714285e-06 1.8 5.790178571428571e-06 0.0
+ 5.799107142857142e-06 0.0 5.799665178571428e-06 1.8 5.807477678571428e-06 1.8 5.808035714285714e-06 0.0
+ 5.816964285714285e-06 0.0 5.817522321428571e-06 1.8 5.825334821428571e-06 1.8 5.8258928571428566e-06 0.0
+ 5.834821428571428e-06 0.0 5.835379464285714e-06 1.8 5.843191964285714e-06 1.8 5.84375e-06 0.0 5.852678571428571e-06 0.0
+ 5.853236607142857e-06 1.8 5.861049107142857e-06 1.8 5.861607142857142e-06 0.0 5.870535714285714e-06 0.0 5.87109375e-06
+ 1.8 5.878906249999999e-06 1.8 5.879464285714285e-06 0.0 5.888392857142856e-06 0.0 5.888950892857142e-06
+ 1.8 5.8967633928571425e-06 1.8 5.897321428571428e-06 0.0 5.9062499999999996e-06 0.0
+ 5.9068080357142855e-06 1.8 5.914620535714286e-06 1.8 5.915178571428571e-06 0.0 5.924107142857143e-06 0.0
+ 5.924665178571428e-06 1.8 5.932477678571428e-06 1.8 5.933035714285714e-06 0.0 5.941964285714285e-06 0.0
+ 5.942522321428571e-06 1.8 5.950334821428571e-06 1.8 5.950892857142857e-06 0.0 5.959821428571428e-06 0.0
+ 5.960379464285714e-06 1.8 5.9681919642857135e-06 1.8 5.968749999999999e-06 0.0 5.977678571428571e-06 0.0
+ 5.9782366071428565e-06 1.8 5.986049107142857e-06 1.8 5.9866071428571426e-06 0.0 5.995535714285714e-06 0.0 5.99609375e-06
+ 1.8 6.004464285714285e-06 1.8 6.005022321428571e-06 0.0 6.012834821428571e-06 0.0 6.013392857142857e-06
+ 1.8 6.022321428571428e-06 1.8 6.022879464285714e-06 0.0 6.030691964285714e-06 0.0 6.031249999999999e-06
+ 1.8 6.040178571428571e-06 1.8 6.040736607142856e-06 0.0 6.0485491071428565e-06 0.0
+ 6.049107142857142e-06 1.8 6.0580357142857135e-06 1.8 6.0585937499999995e-06 0.0 6.06640625e-06 0.0 6.0669642857142856e-06
+ 1.8 6.075892857142857e-06 1.8 6.076450892857143e-06 0.0 6.084263392857143e-06 0.0 6.084821428571428e-06
+ 1.8 6.09375e-06 1.8 6.094308035714285e-06 0.0 6.102120535714285e-06 0.0 6.102678571428571e-06 1.8
+ 6.111607142857142e-06 1.8 6.112165178571428e-06 0.0 6.119977678571428e-06 0.0 6.120535714285714e-06 1.8
+ 6.129464285714285e-06 1.8 6.130022321428571e-06 0.0 6.137834821428571e-06 0.0 6.1383928571428565e-06 1.8
+ 6.1473214285714286e-06 1.8 6.147879464285714e-06 0.0 6.155691964285714e-06 0.0 6.15625e-06 1.8 6.165178571428571e-06 1.8
+ 6.165736607142857e-06 0.0 6.173549107142857e-06 0.0 6.174107142857142e-06 1.8 6.183035714285714e-06 1.8 6.18359375e-06
+ 0.0 6.191406249999999e-06 0.0 6.191964285714285e-06 1.8 6.200892857142856e-06 1.8 6.201450892857142e-06
+ 0.0 6.2092633928571425e-06 0.0 6.209821428571428e-06 1.8 6.2187499999999995e-06 1.8
+ 6.2193080357142854e-06 0.0 6.227120535714286e-06 0.0 6.227678571428571e-06 1.8 6.236607142857143e-06 1.8
+ 6.237165178571428e-06 0.0 6.244977678571428e-06 0.0 6.245535714285714e-06 1.8 6.254464285714285e-06 1.8
+ 6.255022321428571e-06 0.0 6.262834821428571e-06 0.0 6.263392857142857e-06 1.8 6.272321428571428e-06 1.8
+ 6.272879464285714e-06 0.0 6.2806919642857135e-06 0.0 6.281249999999999e-06 1.8 6.290178571428571e-06 1.8
+ 6.2907366071428564e-06 0.0 6.298549107142857e-06 0.0 6.2991071428571425e-06 1.8 6.308035714285714e-06 1.8 6.30859375e-06
+ 0.0 6.31640625e-06 0.0 6.316964285714285e-06 1.8 6.326450892857143e-06 1.8 6.327008928571428e-06 0.0
+ 6.333705357142857e-06 0.0 6.334263392857142e-06 1.8 6.344308035714285e-06 1.8 6.344866071428571e-06 0.0
+ 6.351562499999999e-06 0.0 6.352120535714285e-06 1.8 6.362165178571428e-06 1.8 6.362723214285714e-06 0.0
+ 6.3694196428571426e-06 0.0 6.3699776785714285e-06 1.8 6.380022321428571e-06 1.8 6.3805803571428565e-06 0.0
+ 6.387276785714285e-06 0.0 6.387834821428571e-06 1.8 6.397879464285714e-06 1.8 6.3984375e-06 0.0 6.405133928571428e-06 0.0
+ 6.405691964285714e-06 1.8 6.415736607142857e-06 1.8 6.416294642857142e-06 0.0 6.422991071428571e-06 0.0
+ 6.423549107142856e-06 1.8 6.433593749999999e-06 1.8 6.434151785714285e-06 0.0 6.4408482142857135e-06 0.0
+ 6.4414062499999994e-06 1.8 6.4514508928571424e-06 1.8 6.452008928571428e-06 0.0 6.458705357142857e-06 0.0
+ 6.459263392857143e-06 1.8 6.469308035714286e-06 1.8 6.469866071428571e-06 0.0 6.4765625e-06 0.0 6.477120535714285e-06 1.8
+ 6.487165178571428e-06 1.8 6.487723214285714e-06 0.0 6.494419642857142e-06 0.0 6.494977678571428e-06 1.8
+ 6.505022321428571e-06 1.8 6.505580357142857e-06 0.0 6.512276785714285e-06 0.0 6.512834821428571e-06 1.8
+ 6.522879464285713e-06 1.8 6.523437499999999e-06 0.0 6.530133928571428e-06 0.0 6.530691964285714e-06 1.8
+ 6.540736607142857e-06 1.8 6.5412946428571425e-06 0.0 6.547991071428571e-06 0.0 6.548549107142857e-06 1.8 6.55859375e-06
+ 1.8 6.559151785714286e-06 0.0 6.565848214285714e-06 0.0 6.56640625e-06 1.8 6.576450892857142e-06 1.8
+ 6.577008928571428e-06 0.0 6.583705357142856e-06 0.0 6.584263392857142e-06 1.8 6.594308035714285e-06 1.8
+ 6.594866071428571e-06 0.0 6.6015624999999995e-06 0.0 6.6021205357142854e-06 1.8 6.612165178571428e-06 1.8
+ 6.6127232142857135e-06 0.0 6.619419642857143e-06 0.0 6.619977678571428e-06 1.8 6.630022321428571e-06 1.8
+ 6.630580357142857e-06 0.0 6.637276785714285e-06 0.0 6.637834821428571e-06 1.8 6.647879464285714e-06 1.8 6.6484375e-06 0.0
+ 6.655133928571428e-06 0.0 6.655691964285714e-06 1.8 6.665736607142857e-06 1.8 6.666294642857142e-06 0.0
+ 6.6724330357142855e-06 0.0 6.672991071428571e-06 1.8 6.684151785714285e-06 1.8 6.684709821428571e-06 0.0
+ 6.690290178571428e-06 0.0 6.690848214285714e-06 1.8 6.7020089285714285e-06 1.8 6.7025669642857135e-06 0.0
+ 6.708147321428571e-06 0.0 6.708705357142857e-06 1.8 6.719866071428571e-06 1.8 6.720424107142857e-06 0.0
+ 6.726004464285714e-06 0.0 6.726562499999999e-06 1.8 6.737723214285714e-06 1.8 6.73828125e-06 0.0 6.7438616071428564e-06
+ 0.0 6.744419642857142e-06 1.8 6.755580357142856e-06 1.8 6.756138392857142e-06 0.0 6.76171875e-06 0.0
+ 6.7622767857142855e-06 1.8 6.7734374999999995e-06 1.8 6.773995535714285e-06 0.0 6.779575892857143e-06 0.0
+ 6.780133928571428e-06 1.8 6.791294642857143e-06 1.8 6.791852678571428e-06 0.0 6.797433035714285e-06 0.0
+ 6.797991071428571e-06 1.8 6.809151785714285e-06 1.8 6.809709821428571e-06 0.0 6.815290178571428e-06 0.0
+ 6.815848214285714e-06 1.8 6.827008928571428e-06 1.8 6.827566964285714e-06 0.0 6.833147321428571e-06 0.0
+ 6.8337053571428565e-06 1.8 6.844866071428571e-06 1.8 6.845424107142856e-06 0.0 6.851004464285714e-06 0.0 6.8515625e-06 1.8
+ 6.862723214285714e-06 1.8 6.8632812499999995e-06 0.0 6.868861607142857e-06 0.0 6.869419642857142e-06 1.8
+ 6.880580357142857e-06 1.8 6.881138392857143e-06 0.0 6.886718749999999e-06 0.0 6.887276785714285e-06 1.8
+ 6.898437499999999e-06 1.8 6.898995535714285e-06 0.0 6.9045758928571424e-06 0.0 6.905133928571428e-06 1.8
+ 6.916294642857142e-06 1.8 6.916852678571428e-06 0.0 6.922433035714286e-06 0.0 6.922991071428571e-06 1.8
+ 6.9341517857142855e-06 1.8 6.9347098214285705e-06 0.0 6.940290178571428e-06 0.0 6.940848214285714e-06 1.8
+ 6.952008928571428e-06 1.8 6.952566964285714e-06 0.0 6.958147321428571e-06 0.0 6.958705357142857e-06 1.8
+ 6.969866071428571e-06 1.8 6.970424107142857e-06 0.0 6.976004464285713e-06 0.0 6.976562499999999e-06 1.8
+ 6.987723214285714e-06 1.8 6.988281249999999e-06 0.0 6.993861607142857e-06 0.0 6.9944196428571425e-06 1.8
+ 7.0055803571428564e-06 1.8 7.006138392857142e-06 0.0 7.01171875e-06 0.0 7.012276785714285e-06 1.8 7.0234375e-06 1.8
+ 7.0239955357142855e-06 0.0 7.029575892857142e-06 0.0 7.030133928571428e-06 1.8 7.041294642857142e-06 1.8
+ 7.041852678571428e-06 0.0 7.047433035714285e-06 0.0 7.047991071428571e-06 1.8 7.059151785714285e-06 1.8
+ 7.059709821428571e-06 0.0 7.065290178571428e-06 0.0 7.0658482142857135e-06 1.8 7.077008928571428e-06 1.8
+ 7.077566964285714e-06 0.0 7.082589285714285e-06 0.0 7.083147321428571e-06 1.8 7.0954241071428565e-06 1.8
+ 7.095982142857142e-06 0.0 7.100446428571428e-06 0.0 7.101004464285714e-06 1.8 7.11328125e-06 1.8 7.113839285714286e-06
+ 0.0 7.118303571428571e-06 0.0 7.118861607142856e-06 1.8 7.131138392857142e-06 1.8 7.131696428571428e-06
+ 0.0 7.1361607142857135e-06 0.0 7.136718749999999e-06 1.8 7.148995535714285e-06 1.8
+ 7.149553571428571e-06 0.0 7.154017857142857e-06 0.0 7.154575892857143e-06 1.8 7.166852678571428e-06 1.8
+ 7.167410714285713e-06 0.0 7.171875e-06 0.0 7.172433035714285e-06 1.8 7.184709821428571e-06 1.8 7.185267857142857e-06 0.0
+ 7.189732142857142e-06 0.0 7.190290178571428e-06 1.8 7.202566964285714e-06 1.8 7.203125e-06 0.0 7.207589285714285e-06 0.0
+ 7.208147321428571e-06 1.8 7.220424107142857e-06 1.8 7.220982142857142e-06 0.0 7.225446428571428e-06 0.0
+ 7.2260044642857136e-06 1.8 7.238281249999999e-06 1.8 7.238839285714285e-06 0.0 7.243303571428571e-06 0.0
+ 7.243861607142857e-06 1.8 7.2561383928571425e-06 1.8 7.256696428571428e-06 0.0 7.261160714285714e-06 0.0
+ 7.261718749999999e-06 1.8 7.273995535714285e-06 1.8 7.274553571428571e-06 0.0 7.279017857142856e-06 0.0
+ 7.279575892857142e-06 1.8 7.291852678571428e-06 1.8 7.292410714285714e-06 0.0 7.2968749999999995e-06 0.0
+ 7.297433035714285e-06 1.8 7.309709821428571e-06 1.8 7.310267857142856e-06 0.0 7.314732142857143e-06 0.0
+ 7.315290178571428e-06 1.8 7.3275669642857135e-06 1.8 7.328124999999999e-06 0.0 7.332589285714285e-06 0.0
+ 7.333147321428571e-06 1.8 7.345424107142857e-06 1.8 7.3459821428571426e-06 0.0 7.350446428571428e-06 0.0
+ 7.351004464285714e-06 1.8 7.36328125e-06 1.8 7.363839285714285e-06 0.0 7.368303571428571e-06 0.0 7.368861607142856e-06
+ 1.8 7.381138392857142e-06 1.8 7.381696428571428e-06 0.0 7.386160714285714e-06 0.0
+ 7.3867187499999996e-06 1.8 7.398995535714285e-06 1.8 7.399553571428571e-06 0.0 7.404017857142857e-06 0.0
+ 7.404575892857143e-06 1.8 7.416852678571428e-06 1.8 7.4174107142857136e-06 0.0 7.421874999999999e-06 0.0
+ 7.422433035714285e-06 1.8 7.434709821428571e-06 1.8 7.435267857142857e-06 0.0 7.439732142857142e-06 0.0
+ 7.440290178571428e-06 1.8 7.452566964285714e-06 1.8 7.453124999999999e-06 0.0 7.4575892857142855e-06 0.0
+ 7.4581473214285705e-06 1.8 7.470424107142856e-06 1.8 7.470982142857142e-06 0.0 7.475446428571428e-06 0.0
+ 7.476004464285714e-06 1.8 7.4882812499999995e-06 1.8 7.488839285714285e-06 0.0 7.493303571428571e-06 0.0
+ 7.493861607142857e-06 1.8 7.506138392857143e-06 1.8 7.506696428571428e-06 0.0 7.511160714285714e-06 0.0
+ 7.511718749999999e-06 1.8 7.523995535714285e-06 1.8 7.524553571428571e-06 0.0 7.5290178571428565e-06 0.0
+ 7.529575892857142e-06 1.8 7.541852678571428e-06 1.8 7.542410714285714e-06 0.0 7.546875e-06 0.0 7.5474330357142855e-06 1.8
+ 7.5597098214285705e-06 1.8 7.560267857142856e-06 0.0 7.564732142857142e-06 0.0 7.565290178571428e-06 1.8
+ 7.577566964285714e-06 1.8 7.5781249999999995e-06 0.0 7.582589285714285e-06 0.0 7.583147321428571e-06 1.8
+ 7.595424107142857e-06 1.8 7.595982142857143e-06 0.0 7.600446428571428e-06 0.0 7.601004464285713e-06 1.8
+ 7.613281249999999e-06 1.8 7.613839285714285e-06 0.0 7.618303571428571e-06 0.0 7.6188616071428565e-06 1.8
+ 7.631138392857143e-06 1.8 7.631696428571428e-06 0.0 7.636160714285714e-06 0.0 7.636718749999999e-06 1.8
+ 7.648995535714285e-06 1.8 7.64955357142857e-06 0.0 7.654017857142856e-06 0.0 7.654575892857143e-06 1.8
+ 7.666852678571428e-06 1.8 7.667410714285715e-06 0.0 7.671875e-06 0.0 7.672433035714285e-06 1.8 7.68470982142857e-06 1.8
+ 7.685267857142857e-06 0.0 7.689732142857142e-06 0.0 7.690290178571428e-06 1.8 7.702566964285714e-06 1.8 7.703125e-06 0.0
+ 7.707589285714285e-06 0.0 7.708147321428572e-06 1.8 7.720424107142856e-06 1.8 7.720982142857142e-06 0.0
+ 7.725446428571429e-06 0.0 7.726004464285714e-06 1.8 7.738281249999999e-06 1.8 7.738839285714286e-06 0.0
+ 7.743303571428571e-06 0.0 7.743861607142856e-06 1.8 7.756138392857143e-06 1.8 7.756696428571428e-06 0.0
+ 7.761160714285713e-06 0.0 7.76171875e-06 1.8 7.773995535714285e-06 1.8 7.77455357142857e-06 0.0 7.779017857142856e-06 0.0
+ 7.779575892857143e-06 1.8 7.791852678571427e-06 1.8 7.792410714285714e-06 0.0 7.796875e-06 0.0 7.797433035714285e-06 1.8
+ 7.809709821428571e-06 1.8 7.810267857142857e-06 0.0 7.814732142857142e-06 0.0 7.815290178571427e-06 1.8
+ 7.827566964285714e-06 1.8 7.828124999999999e-06 0.0 7.832589285714284e-06 0.0 7.833147321428571e-06 1.8
+ 7.845424107142856e-06 1.8 7.845982142857143e-06 0.0 7.850446428571428e-06 0.0 7.851004464285714e-06 1.8 7.86328125e-06
+ 1.8 7.863839285714285e-06 0.0 7.86830357142857e-06 0.0 7.868861607142856e-06 1.8 7.881138392857142e-06
+ 1.8 7.881696428571428e-06 0.0 7.886160714285713e-06 0.0 7.88671875e-06 1.8 7.898995535714285e-06 1.8
+ 7.899553571428572e-06 0.0 7.904017857142857e-06 0.0 7.904575892857142e-06 1.8 7.916852678571429e-06 1.8
+ 7.917410714285714e-06 0.0 7.921875e-06 0.0 7.922433035714284e-06 1.8 7.934709821428571e-06 1.8 7.935267857142856e-06 0.0
+ 7.939732142857142e-06 0.0 7.940290178571429e-06 1.8 7.952566964285713e-06 1.8 7.953125e-06 0.0 7.957589285714286e-06 0.0
+ 7.95814732142857e-06 1.8 7.970424107142856e-06 1.8 7.970982142857143e-06 0.0 7.975446428571428e-06 0.0
+ 7.976004464285713e-06 1.8 7.98828125e-06 1.8 7.988839285714285e-06 0.0 7.99330357142857e-06 0.0 7.993861607142857e-06 1.8
+ 8.006138392857142e-06 1.8 8.006696428571427e-06 0.0 8.011160714285714e-06 0.0 8.01171875e-06 1.8 8.023995535714284e-06
+ 1.8 8.024553571428571e-06 0.0 8.029017857142857e-06 0.0 8.029575892857142e-06 1.8 8.041852678571428e-06
+ 1.8 8.042410714285714e-06 0.0 8.046874999999999e-06 0.0 8.047433035714286e-06 1.8 8.05970982142857e-06
+ 1.8 8.060267857142856e-06 0.0 8.064732142857143e-06 0.0 8.065290178571428e-06 1.8 8.077566964285713e-06
+ 1.8 8.078125e-06 0.0 8.082589285714285e-06 0.0 8.08314732142857e-06 1.8 8.095424107142857e-06 1.8
+ 8.095982142857142e-06 0.0 8.100446428571428e-06 0.0 8.101004464285715e-06 1.8 8.11328125e-06 1.8 8.113839285714284e-06
+ 0.0 8.11830357142857e-06 0.0 8.118861607142857e-06 1.8 8.131138392857142e-06 1.8 8.131696428571429e-06
+ 0.0 8.136160714285714e-06 0.0 8.136718749999999e-06 1.8 8.148995535714286e-06 1.8 8.14955357142857e-06
+ 0.0 8.154017857142856e-06 0.0 8.154575892857141e-06 1.8 8.166852678571428e-06 1.8 8.167410714285713e-06
+ 0.0 8.171874999999999e-06 0.0 8.172433035714285e-06 1.8 8.18470982142857e-06 1.8 8.185267857142857e-06
+ 0.0 8.189732142857143e-06 0.0 8.190290178571428e-06 1.8 8.202566964285714e-06 1.8 8.203125e-06 0.0
+ 8.207589285714285e-06 0.0 8.20814732142857e-06 1.8 8.220424107142857e-06 1.8 8.220982142857142e-06 0.0
+ 8.225446428571427e-06 0.0 8.226004464285714e-06 1.8 8.238281249999999e-06 1.8 8.238839285714286e-06 0.0
+ 8.243303571428571e-06 0.0 8.243861607142856e-06 1.8 8.256138392857143e-06 1.8 8.256696428571428e-06 0.0
+ 8.261160714285714e-06 0.0 8.261718749999999e-06 1.8 8.273995535714285e-06 1.8 8.27455357142857e-06 0.0
+ 8.279017857142856e-06 0.0 8.279575892857143e-06 1.8 8.291852678571428e-06 1.8 8.292410714285714e-06 0.0 8.296875e-06 0.0
+ 8.297433035714285e-06 1.8 8.30970982142857e-06 1.8 8.310267857142857e-06 0.0 8.314732142857142e-06 0.0
+ 8.315290178571427e-06 1.8 8.327566964285714e-06 1.8 8.328124999999999e-06 0.0 8.332589285714285e-06 0.0
+ 8.333147321428571e-06 1.8 8.345424107142856e-06 1.8 8.345982142857141e-06 0.0 8.350446428571429e-06 0.0
+ 8.351004464285714e-06 1.8 8.363281249999999e-06 1.8 8.363839285714285e-06 0.0 8.368303571428571e-06 0.0
+ 8.368861607142856e-06 1.8 8.381138392857143e-06 1.8 8.381696428571428e-06 0.0 8.386160714285713e-06 0.0 8.38671875e-06
+ 1.8 8.398995535714285e-06 1.8 8.39955357142857e-06 0.0 8.404017857142856e-06 0.0 8.404575892857142e-06
+ 1.8 8.416852678571427e-06 1.8 8.417410714285714e-06 0.0 8.421875e-06 0.0 8.422433035714285e-06 1.8
+ 8.434709821428571e-06 1.8 8.435267857142856e-06 0.0 8.439732142857142e-06 0.0 8.440290178571429e-06 1.8
+ 8.452566964285714e-06 1.8 8.453124999999999e-06 0.0 8.457589285714284e-06 0.0 8.458147321428571e-06 1.8
+ 8.470424107142856e-06 1.8 8.470982142857143e-06 0.0 8.475446428571428e-06 0.0 8.476004464285713e-06 1.8 8.48828125e-06
+ 1.8 8.488839285714285e-06 0.0 8.49330357142857e-06 0.0 8.493861607142856e-06 1.8 8.506138392857142e-06
+ 1.8 8.506696428571427e-06 0.0 8.511160714285713e-06 0.0 8.51171875e-06 1.8 8.523995535714285e-06 1.8
+ 8.524553571428571e-06 0.0 8.529017857142857e-06 0.0 8.529575892857142e-06 1.8 8.541852678571429e-06 1.8
+ 8.542410714285714e-06 0.0 8.546875e-06 0.0 8.547433035714284e-06 1.8 8.559709821428571e-06 1.8 8.560267857142856e-06 0.0
+ 8.564732142857142e-06 0.0 8.565290178571428e-06 1.8 8.577566964285713e-06 1.8 8.578125e-06 0.0 8.582589285714286e-06 0.0
+ 8.58314732142857e-06 1.8 8.595424107142856e-06 1.8 8.595982142857142e-06 0.0 8.600446428571428e-06 0.0
+ 8.601004464285713e-06 1.8 8.61328125e-06 1.8 8.613839285714285e-06 0.0 8.61830357142857e-06 0.0 8.618861607142857e-06 1.8
+ 8.631138392857142e-06 1.8 8.631696428571427e-06 0.0 8.636160714285714e-06 0.0 8.63671875e-06 1.8 8.648995535714284e-06
+ 1.8 8.649553571428571e-06 0.0 8.654017857142857e-06 0.0 8.654575892857142e-06 1.8 8.666852678571428e-06
+ 1.8 8.667410714285713e-06 0.0 8.671874999999999e-06 0.0 8.672433035714286e-06 1.8 8.68470982142857e-06
+ 1.8 8.685267857142856e-06 0.0 8.689732142857143e-06 0.0 8.690290178571428e-06 1.8 8.702566964285713e-06
+ 1.8 8.703125e-06 0.0 8.707589285714285e-06 0.0 8.70814732142857e-06 1.8 8.720424107142857e-06 1.8
+ 8.720982142857142e-06 0.0 8.725446428571428e-06 0.0 8.726004464285714e-06 1.8 8.73828125e-06 1.8 8.738839285714284e-06
+ 0.0 8.74330357142857e-06 0.0 8.743861607142857e-06 1.8 8.756138392857142e-06 1.8 8.756696428571428e-06
+ 0.0 8.761160714285714e-06 0.0 8.761718749999999e-06 1.8 8.773995535714286e-06 1.8 8.77455357142857e-06
+ 0.0 8.779017857142856e-06 0.0 8.779575892857141e-06 1.8 8.791852678571428e-06 1.8 8.792410714285713e-06
+ 0.0 8.796874999999999e-06 0.0 8.797433035714285e-06 1.8 8.80970982142857e-06 1.8 8.810267857142857e-06
+ 0.0 8.814732142857143e-06 0.0 8.815290178571428e-06 1.8 8.827566964285714e-06 1.8 8.828125e-06 0.0
+ 8.832589285714285e-06 0.0 8.83314732142857e-06 1.8 8.845424107142857e-06 1.8 8.845982142857142e-06 0.0
+ 8.850446428571427e-06 0.0 8.851004464285714e-06 1.8 8.863281249999999e-06 1.8 8.863839285714286e-06 0.0
+ 8.868303571428571e-06 0.0 8.868861607142856e-06 1.8 8.881138392857143e-06 1.8 8.881696428571428e-06 0.0
+ 8.886160714285714e-06 0.0 8.886718749999999e-06 1.8 8.898995535714285e-06 1.8 8.89955357142857e-06 0.0
+ 8.904017857142856e-06 0.0 8.904575892857143e-06 1.8 8.916852678571428e-06 1.8 8.917410714285714e-06 0.0
+ 8.922433035714285e-06 0.0 8.92299107142857e-06 1.8 8.934151785714285e-06 1.8 8.93470982142857e-06 0.0
+ 8.940290178571427e-06 0.0 8.940848214285714e-06 1.8 8.952008928571427e-06 1.8 8.952566964285714e-06 0.0
+ 8.958147321428571e-06 0.0 8.958705357142856e-06 1.8 8.969866071428571e-06 1.8 8.970424107142856e-06 0.0
+ 8.976004464285714e-06 0.0 8.976562499999999e-06 1.8 8.987723214285714e-06 1.8 8.988281249999999e-06 0.0
+ 8.993861607142856e-06 0.0 8.994419642857143e-06 1.8 9.005580357142856e-06 1.8 9.006138392857143e-06 0.0 9.01171875e-06
+ 0.0 9.012276785714285e-06 1.8 9.0234375e-06 1.8 9.023995535714285e-06 0.0 9.029575892857142e-06 0.0
+ 9.030133928571427e-06 1.8 9.041294642857142e-06 1.8 9.041852678571427e-06 0.0 9.047433035714285e-06 0.0
+ 9.047991071428571e-06 1.8 9.059151785714285e-06 1.8 9.059709821428571e-06 0.0 9.065290178571429e-06 0.0
+ 9.065848214285714e-06 1.8 9.077008928571429e-06 1.8 9.077566964285714e-06 0.0 9.083147321428571e-06 0.0
+ 9.083705357142856e-06 1.8 9.094866071428571e-06 1.8 9.095424107142856e-06 0.0 9.101004464285713e-06 0.0 9.1015625e-06 1.8
+ 9.112723214285713e-06 1.8 9.11328125e-06 0.0 9.118861607142856e-06 0.0 9.119419642857142e-06 1.8 9.130580357142857e-06
+ 1.8 9.131138392857142e-06 0.0 9.13671875e-06 0.0 9.137276785714285e-06 1.8 9.1484375e-06 1.8
+ 9.148995535714285e-06 0.0 9.154575892857142e-06 0.0 9.155133928571427e-06 1.8 9.166294642857142e-06 1.8
+ 9.166852678571429e-06 0.0 9.172433035714284e-06 0.0 9.172991071428571e-06 1.8 9.184151785714284e-06 1.8
+ 9.184709821428571e-06 0.0 9.190290178571428e-06 0.0 9.190848214285713e-06 1.8 9.202008928571428e-06 1.8
+ 9.202566964285713e-06 0.0 9.20814732142857e-06 0.0 9.208705357142856e-06 1.8 9.21986607142857e-06 1.8
+ 9.220424107142856e-06 0.0 9.226004464285713e-06 0.0 9.2265625e-06 1.8 9.237723214285713e-06 1.8 9.23828125e-06 0.0
+ 9.243861607142857e-06 0.0 9.244419642857142e-06 1.8 9.255580357142857e-06 1.8 9.256138392857142e-06 0.0 9.26171875e-06
+ 0.0 9.262276785714284e-06 1.8 9.2734375e-06 1.8 9.273995535714284e-06 0.0 9.279575892857142e-06 0.0
+ 9.280133928571428e-06 1.8 9.291294642857142e-06 1.8 9.291852678571428e-06 0.0 9.297433035714286e-06 0.0
+ 9.29799107142857e-06 1.8 9.309151785714286e-06 1.8 9.30970982142857e-06 0.0 9.315290178571428e-06 0.0
+ 9.315848214285713e-06 1.8 9.327008928571428e-06 1.8 9.327566964285713e-06 0.0 9.333705357142857e-06 0.0
+ 9.334263392857142e-06 1.8 9.344308035714285e-06 1.8 9.34486607142857e-06 0.0 9.3515625e-06 0.0 9.352120535714285e-06 1.8
+ 9.362165178571427e-06 1.8 9.362723214285714e-06 0.0 9.369419642857142e-06 0.0 9.369977678571429e-06 1.8
+ 9.380022321428572e-06 1.8 9.380580357142857e-06 0.0 9.387276785714286e-06 0.0 9.387834821428571e-06 1.8
+ 9.397879464285714e-06 1.8 9.398437499999999e-06 0.0 9.405133928571428e-06 0.0 9.405691964285713e-06 1.8
+ 9.415736607142856e-06 1.8 9.416294642857143e-06 0.0 9.42299107142857e-06 0.0 9.423549107142857e-06 1.8
+ 9.433593749999998e-06 1.8 9.434151785714285e-06 0.0 9.440848214285713e-06 0.0 9.44140625e-06 1.8 9.451450892857143e-06
+ 1.8 9.452008928571428e-06 0.0 9.458705357142857e-06 0.0 9.459263392857142e-06 1.8 9.469308035714285e-06
+ 1.8 9.469866071428572e-06 0.0 9.476562499999999e-06 0.0 9.477120535714286e-06 1.8 9.487165178571427e-06
+ 1.8 9.487723214285714e-06 0.0 9.494419642857141e-06 0.0 9.494977678571428e-06 1.8 9.505022321428571e-06
+ 1.8 9.505580357142856e-06 0.0 9.512276785714285e-06 0.0 9.51283482142857e-06 1.8 9.522879464285713e-06
+ 1.8 9.523437499999999e-06 0.0 9.530133928571428e-06 0.0 9.530691964285713e-06 1.8 9.540736607142856e-06
+ 1.8 9.541294642857143e-06 0.0 9.54799107142857e-06 0.0 9.548549107142857e-06 1.8 9.55859375e-06 1.8
+ 9.559151785714285e-06 0.0 9.565848214285714e-06 0.0 9.56640625e-06 1.8 9.576450892857142e-06 1.8 9.577008928571427e-06
+ 0.0 9.583705357142856e-06 0.0 9.584263392857141e-06 1.8 9.594308035714284e-06 1.8 9.594866071428571e-06
+ 0.0 9.601562499999999e-06 0.0 9.602120535714286e-06 1.8 9.612165178571428e-06 1.8 9.612723214285714e-06
+ 0.0 9.619419642857143e-06 0.0 9.619977678571428e-06 1.8 9.63002232142857e-06 1.8 9.630580357142856e-06
+ 0.0 9.637276785714285e-06 0.0 9.63783482142857e-06 1.8 9.647879464285713e-06 1.8 9.6484375e-06 0.0
+ 9.655133928571427e-06 0.0 9.655691964285714e-06 1.8 9.665736607142857e-06 1.8 9.666294642857142e-06 0.0
+ 9.672991071428571e-06 0.0 9.673549107142856e-06 1.8 9.683035714285714e-06 1.8 9.68359375e-06 0.0 9.691406249999999e-06
+ 0.0 9.691964285714286e-06 1.8 9.700892857142857e-06 1.8 9.701450892857142e-06 0.0 9.709263392857143e-06
+ 0.0 9.709821428571428e-06 1.8 9.718749999999999e-06 1.8 9.719308035714286e-06 0.0 9.727120535714285e-06
+ 0.0 9.72767857142857e-06 1.8 9.736607142857141e-06 1.8 9.737165178571428e-06 0.0 9.744977678571427e-06
+ 0.0 9.745535714285714e-06 1.8 9.754464285714285e-06 1.8 9.75502232142857e-06 0.0 9.762834821428572e-06
+ 0.0 9.763392857142857e-06 1.8 9.772321428571428e-06 1.8 9.772879464285713e-06 0.0 9.780691964285714e-06
+ 0.0 9.781249999999999e-06 1.8 9.79017857142857e-06 1.8 9.790736607142857e-06 0.0 9.798549107142856e-06
+ 0.0 9.799107142857143e-06 1.8 9.808035714285714e-06 1.8 9.808593749999999e-06 0.0 9.816406249999998e-06
+ 0.0 9.816964285714285e-06 1.8 9.825892857142856e-06 1.8 9.826450892857141e-06 0.0 9.834263392857142e-06
+ 0.0 9.834821428571428e-06 1.8 9.843749999999999e-06 1.8 9.844308035714285e-06 0.0 9.852120535714285e-06
+ 0.0 9.85267857142857e-06 1.8 9.861607142857143e-06 1.8 9.862165178571428e-06 0.0 9.869977678571427e-06
+ 0.0 9.870535714285714e-06 1.8 9.879464285714285e-06 1.8 9.88002232142857e-06 0.0 9.887834821428571e-06
+ 0.0 9.888392857142856e-06 1.8 9.897321428571427e-06 1.8 9.897879464285714e-06 0.0 9.905691964285713e-06
+ 0.0 9.906249999999999e-06 1.8 9.915178571428571e-06 1.8 9.915736607142856e-06 0.0 9.923549107142856e-06
+ 0.0 9.924107142857143e-06 1.8 9.933035714285714e-06 1.8 9.933593749999999e-06 0.0 9.94140625e-06 0.0
+ 9.941964285714285e-06 1.8 9.950892857142856e-06 1.8 9.951450892857143e-06 0.0 9.959263392857142e-06 0.0
+ 9.959821428571427e-06 1.8 9.96875e-06 1.8 9.969308035714285e-06 0.0 9.977120535714284e-06 0.0 9.977678571428571e-06 1.8
+ 9.986607142857142e-06 1.8 9.987165178571427e-06 0.0 9.994977678571428e-06 0.0 9.995535714285714e-06 1.8 1.000390625e-05
+ 1.8 1.0004464285714285e-05 0.0 1.0013392857142856e-05 0.0 1.0013950892857143e-05 1.8
+ 1.0021763392857142e-05 1.8 1.0022321428571427e-05 0.0 1.003125e-05 0.0 1.0031808035714285e-05 1.8 1.0039620535714284e-05
+ 1.8 1.0040178571428571e-05 0.0 1.0049107142857142e-05 0.0 1.0049665178571427e-05 1.8
+ 1.0057477678571428e-05 1.8 1.0058035714285713e-05 0.0 1.0066964285714285e-05 0.0 1.0067522321428571e-05 1.8
+ 1.007533482142857e-05 1.8 1.0075892857142856e-05 0.0 1.0084821428571429e-05 0.0 1.0085379464285714e-05 1.8
+ 1.0093191964285713e-05 1.8 1.009375e-05 0.0 1.0102678571428571e-05 0.0 1.0103236607142856e-05 1.8 1.0111049107142857e-05
+ 1.8 1.0111607142857142e-05 0.0 1.0120535714285713e-05 0.0 1.012109375e-05 1.8 1.012890625e-05 1.8
+ 1.0129464285714284e-05 0.0 1.0138392857142857e-05 0.0 1.0138950892857142e-05 1.8 1.0146763392857142e-05 1.8
+ 1.0147321428571428e-05 0.0 1.015625e-05 0.0 1.0156808035714285e-05 1.8 1.0164620535714286e-05 1.8 1.016517857142857e-05
+ 0.0 1.0174107142857142e-05 0.0 1.0174665178571429e-05 1.8 1.0182477678571428e-05 1.8
+ 1.0183035714285713e-05 0.0 1.0191964285714284e-05 0.0 1.0192522321428571e-05 1.8 1.020033482142857e-05 1.8
+ 1.0200892857142857e-05 0.0 1.0209821428571428e-05 0.0 1.0210379464285713e-05 1.8 1.0218191964285714e-05 1.8 1.021875e-05
+ 0.0 1.022767857142857e-05 0.0 1.0228236607142856e-05 1.8 1.0236049107142857e-05 1.8
+ 1.0236607142857142e-05 0.0 1.0245535714285713e-05 0.0 1.024609375e-05 1.8 1.0253906249999999e-05 1.8
+ 1.0254464285714286e-05 0.0 1.0263392857142857e-05 0.0 1.0263950892857142e-05 1.8 1.0271763392857143e-05 1.8
+ 1.0272321428571428e-05 0.0 1.028125e-05 0.0 1.0281808035714284e-05 1.8 1.0289620535714285e-05 1.8 1.029017857142857e-05
+ 0.0 1.0299107142857142e-05 0.0 1.0299665178571428e-05 1.8 1.0307477678571428e-05 1.8
+ 1.0308035714285714e-05 0.0 1.0316964285714286e-05 0.0 1.031752232142857e-05 1.8 1.0324776785714285e-05 1.8
+ 1.032533482142857e-05 0.0 1.0335379464285713e-05 0.0 1.03359375e-05 1.8 1.0342633928571427e-05 1.8 1.0343191964285714e-05
+ 0.0 1.0353236607142857e-05 0.0 1.0353794642857142e-05 1.8 1.0360491071428571e-05 1.8
+ 1.0361049107142856e-05 0.0 1.037109375e-05 0.0 1.0371651785714284e-05 1.8 1.0378348214285714e-05 1.8
+ 1.0378906249999999e-05 0.0 1.0388950892857142e-05 0.0 1.0389508928571428e-05 1.8 1.0396205357142856e-05 1.8
+ 1.0396763392857143e-05 0.0 1.0406808035714286e-05 0.0 1.040736607142857e-05 1.8 1.04140625e-05 1.8 1.0414620535714285e-05
+ 0.0 1.0424665178571428e-05 0.0 1.0425223214285713e-05 1.8 1.0431919642857142e-05 1.8
+ 1.0432477678571427e-05 0.0 1.044252232142857e-05 0.0 1.0443080357142857e-05 1.8 1.0449776785714285e-05 1.8
+ 1.0450334821428571e-05 0.0 1.0460379464285714e-05 0.0 1.04609375e-05 1.8 1.0467633928571429e-05 1.8 1.0468191964285714e-05
+ 0.0 1.0478236607142857e-05 0.0 1.0478794642857142e-05 1.8 1.0485491071428571e-05 1.8
+ 1.0486049107142856e-05 0.0 1.0496093749999999e-05 0.0 1.0496651785714286e-05 1.8 1.0503348214285713e-05 1.8
+ 1.050390625e-05 0.0 1.0513950892857143e-05 0.0 1.0514508928571428e-05 1.8 1.0521205357142857e-05 1.8
+ 1.0521763392857142e-05 0.0 1.0531808035714285e-05 0.0 1.053236607142857e-05 1.8 1.05390625e-05 1.8 1.0539620535714285e-05
+ 0.0 1.0549665178571428e-05 0.0 1.0550223214285714e-05 1.8 1.0556919642857142e-05 1.8
+ 1.0557477678571429e-05 0.0 1.056752232142857e-05 0.0 1.0568080357142857e-05 1.8 1.0574776785714284e-05 1.8
+ 1.0575334821428571e-05 0.0 1.0585379464285714e-05 0.0 1.0585937499999999e-05 1.8 1.0592633928571428e-05 1.8
+ 1.0593191964285713e-05 0.0 1.0603236607142856e-05 0.0 1.0603794642857141e-05 1.8 1.061049107142857e-05 1.8
+ 1.0611049107142856e-05 0.0 1.0621093749999999e-05 0.0 1.0621651785714285e-05 1.8 1.0628348214285713e-05 1.8
+ 1.062890625e-05 0.0 1.0638950892857143e-05 0.0 1.0639508928571428e-05 1.8 1.0646205357142857e-05 1.8
+ 1.0646763392857142e-05 0.0 1.0656808035714285e-05 0.0 1.065736607142857e-05 1.8 1.06640625e-05 1.8 1.0664620535714284e-05
+ 0.0 1.0675223214285714e-05 0.0 1.0675781249999999e-05 1.8 1.0681361607142856e-05 1.8
+ 1.0681919642857141e-05 0.0 1.0693080357142856e-05 0.0 1.0693638392857141e-05 1.8 1.0699218749999999e-05 1.8
+ 1.0699776785714286e-05 0.0 1.0710937499999999e-05 0.0 1.0711495535714285e-05 1.8 1.0717075892857143e-05 1.8
+ 1.0717633928571428e-05 0.0 1.0728794642857143e-05 0.0 1.0729352678571428e-05 1.8 1.0734933035714285e-05 1.8
+ 1.073549107142857e-05 0.0 1.0746651785714285e-05 0.0 1.074720982142857e-05 1.8 1.0752790178571427e-05 1.8
+ 1.0753348214285714e-05 0.0 1.0764508928571427e-05 0.0 1.0765066964285714e-05 1.8 1.0770647321428571e-05 1.8
+ 1.0771205357142856e-05 0.0 1.0782366071428571e-05 0.0 1.0782924107142856e-05 1.8 1.0788504464285714e-05 1.8
+ 1.0789062499999999e-05 0.0 1.0800223214285714e-05 0.0 1.0800781249999999e-05 1.8 1.0806361607142856e-05 1.8
+ 1.0806919642857143e-05 0.0 1.0818080357142856e-05 0.0 1.0818638392857143e-05 1.8 1.0824218749999998e-05 1.8
+ 1.0824776785714285e-05 0.0 1.08359375e-05 0.0 1.0836495535714285e-05 1.8 1.0842075892857142e-05 1.8 1.0842633928571427e-05
+ 0.0 1.0853794642857142e-05 0.0 1.0854352678571427e-05 1.8 1.0859933035714285e-05 1.8
+ 1.086049107142857e-05 0.0 1.0871651785714285e-05 0.0 1.0872209821428571e-05 1.8 1.0877790178571427e-05 1.8
+ 1.0878348214285714e-05 0.0 1.0889508928571429e-05 0.0 1.0890066964285714e-05 1.8 1.0895647321428571e-05 1.8
+ 1.0896205357142856e-05 0.0 1.0907366071428571e-05 0.0 1.0907924107142856e-05 1.8 1.0913504464285713e-05 1.8
+ 1.0914062499999998e-05 0.0 1.0925223214285713e-05 0.0 1.092578125e-05 1.8 1.0931361607142856e-05 1.8
+ 1.0931919642857142e-05 0.0 1.0943080357142856e-05 0.0 1.0943638392857142e-05 1.8 1.094921875e-05 1.8
+ 1.0949776785714285e-05 0.0 1.09609375e-05 0.0 1.0961495535714285e-05 1.8 1.0967075892857142e-05 1.8 1.0967633928571427e-05
+ 0.0 1.0978794642857142e-05 0.0 1.0979352678571427e-05 1.8 1.0984933035714284e-05 1.8
+ 1.0985491071428571e-05 0.0 1.0996651785714284e-05 0.0 1.0997209821428571e-05 1.8 1.1002790178571428e-05 1.8
+ 1.1003348214285713e-05 0.0 1.1014508928571428e-05 0.0 1.1015066964285713e-05 1.8 1.102064732142857e-05 1.8
+ 1.1021205357142856e-05 0.0 1.103236607142857e-05 0.0 1.1032924107142856e-05 1.8 1.1038504464285713e-05 1.8 1.10390625e-05
+ 0.0 1.1050223214285713e-05 0.0 1.105078125e-05 1.8 1.1056361607142857e-05 1.8 1.1056919642857142e-05
+ 0.0 1.1068080357142857e-05 0.0 1.1068638392857142e-05 1.8 1.107421875e-05 1.8 1.1074776785714284e-05
+ 0.0 1.1086495535714284e-05 0.0 1.1087053571428571e-05 1.8 1.1091517857142857e-05 1.8
+ 1.1092075892857142e-05 0.0 1.1104352678571428e-05 0.0 1.1104910714285713e-05 1.8 1.1109374999999999e-05 1.8
+ 1.1109933035714286e-05 0.0 1.112220982142857e-05 0.0 1.1122767857142856e-05 1.8 1.1127232142857141e-05 1.8
+ 1.1127790178571428e-05 0.0 1.1140066964285713e-05 0.0 1.1140625e-05 1.8 1.1145089285714285e-05 1.8 1.114564732142857e-05
+ 0.0 1.1157924107142857e-05 0.0 1.1158482142857142e-05 1.8 1.1162946428571428e-05 1.8
+ 1.1163504464285713e-05 0.0 1.117578125e-05 0.0 1.1176339285714284e-05 1.8 1.118080357142857e-05 1.8 1.1181361607142857e-05
+ 0.0 1.1193638392857142e-05 0.0 1.1194196428571428e-05 1.8 1.1198660714285714e-05 1.8
+ 1.1199218749999999e-05 0.0 1.1211495535714286e-05 0.0 1.121205357142857e-05 1.8 1.1216517857142856e-05 1.8
+ 1.1217075892857141e-05 0.0 1.1229352678571428e-05 0.0 1.1229910714285713e-05 1.8 1.1234374999999999e-05 1.8
+ 1.1234933035714285e-05 0.0 1.124720982142857e-05 0.0 1.1247767857142857e-05 1.8 1.1252232142857143e-05 1.8
+ 1.1252790178571428e-05 0.0 1.1265066964285713e-05 0.0 1.1265625e-05 1.8 1.1270089285714285e-05 1.8 1.127064732142857e-05
+ 0.0 1.1282924107142857e-05 0.0 1.1283482142857142e-05 1.8 1.1287946428571427e-05 1.8
+ 1.1288504464285714e-05 0.0 1.1300781249999999e-05 0.0 1.1301339285714286e-05 1.8 1.1305803571428571e-05 1.8
+ 1.1306361607142856e-05 0.0 1.1318638392857141e-05 0.0 1.1319196428571428e-05 1.8 1.1323660714285714e-05 1.8
+ 1.1324218749999999e-05 0.0 1.1336495535714285e-05 0.0 1.133705357142857e-05 1.8 1.1341517857142856e-05 1.8
+ 1.1342075892857143e-05 0.0 1.1354352678571428e-05 0.0 1.1354910714285713e-05 1.8 1.1359375e-05 1.8 1.1359933035714285e-05
+ 0.0 1.137220982142857e-05 0.0 1.1372767857142857e-05 1.8 1.1377232142857142e-05 1.8
+ 1.1377790178571427e-05 0.0 1.1390066964285714e-05 0.0 1.1390624999999999e-05 1.8 1.1395089285714285e-05 1.8
+ 1.1395647321428571e-05 0.0 1.1407924107142856e-05 0.0 1.1408482142857141e-05 1.8 1.1412946428571427e-05 1.8
+ 1.1413504464285714e-05 0.0 1.1425781249999999e-05 0.0 1.1426339285714285e-05 1.8 1.1430803571428571e-05 1.8
+ 1.1431361607142856e-05 0.0 1.1443638392857143e-05 0.0 1.1444196428571428e-05 1.8 1.1448660714285713e-05 1.8
+ 1.1449218749999998e-05 0.0 1.1461495535714285e-05 0.0 1.146205357142857e-05 1.8 1.1466517857142856e-05 1.8
+ 1.1467075892857142e-05 0.0 1.1479352678571427e-05 0.0 1.1479910714285714e-05 1.8 1.1484375e-05 1.8 1.1484933035714285e-05
+ 0.0 1.1497209821428571e-05 0.0 1.1497767857142856e-05 1.8 1.1502232142857142e-05 1.8
+ 1.1502790178571427e-05 0.0 1.1515066964285714e-05 0.0 1.1515624999999999e-05 1.8 1.1520089285714284e-05 1.8
+ 1.1520647321428571e-05 0.0 1.1532924107142856e-05 0.0 1.1533482142857143e-05 1.8 1.1537946428571428e-05 1.8
+ 1.1538504464285713e-05 0.0 1.155078125e-05 0.0 1.1551339285714285e-05 1.8 1.155580357142857e-05 1.8 1.1556361607142856e-05
+ 0.0 1.1568638392857142e-05 0.0 1.1569196428571427e-05 1.8 1.1573660714285713e-05 1.8 1.157421875e-05
+ 0.0 1.1586495535714285e-05 0.0 1.1587053571428571e-05 1.8 1.1591517857142857e-05 1.8
+ 1.1592075892857142e-05 0.0 1.1604352678571427e-05 0.0 1.1604910714285714e-05 1.8 1.1609375e-05 1.8 1.1609933035714284e-05
+ 0.0 1.1622209821428571e-05 0.0 1.1622767857142856e-05 1.8 1.1627232142857142e-05 1.8
+ 1.1627790178571428e-05 0.0 1.1640066964285713e-05 0.0 1.1640624999999998e-05 1.8 1.1645089285714286e-05 1.8
+ 1.164564732142857e-05 0.0 1.1657924107142856e-05 0.0 1.1658482142857142e-05 1.8 1.1662946428571428e-05 1.8
+ 1.1663504464285713e-05 0.0 1.167578125e-05 0.0 1.1676339285714285e-05 1.8 1.168080357142857e-05 1.8 1.1681361607142857e-05
+ 0.0 1.1693638392857142e-05 0.0 1.1694196428571427e-05 1.8 1.1698660714285714e-05 1.8 1.169921875e-05
+ 0.0 1.1711495535714284e-05 0.0 1.1712053571428571e-05 1.8 1.1716517857142857e-05 1.8
+ 1.1717075892857142e-05 0.0 1.1729352678571428e-05 0.0 1.1729910714285713e-05 1.8 1.1734374999999999e-05 1.8
+ 1.1734933035714286e-05 0.0 1.174720982142857e-05 0.0 1.1747767857142856e-05 1.8 1.1752232142857141e-05 1.8
+ 1.1752790178571428e-05 0.0 1.1765066964285713e-05 0.0 1.1765625e-05 1.8 1.1770089285714285e-05 1.8 1.177064732142857e-05
+ 0.0 1.1782924107142857e-05 0.0 1.1783482142857142e-05 1.8 1.1787946428571428e-05 1.8
+ 1.1788504464285713e-05 0.0 1.180078125e-05 0.0 1.1801339285714284e-05 1.8 1.180580357142857e-05 1.8 1.1806361607142857e-05
+ 0.0 1.1818638392857142e-05 0.0 1.1819196428571428e-05 1.8 1.1823660714285714e-05 1.8
+ 1.1824218749999999e-05 0.0 1.1836495535714286e-05 0.0 1.183705357142857e-05 1.8 1.1841517857142856e-05 1.8
+ 1.1842075892857141e-05 0.0 1.1854352678571428e-05 0.0 1.1854910714285713e-05 1.8 1.1859374999999999e-05 1.8
+ 1.1859933035714285e-05 0.0 1.187220982142857e-05 0.0 1.1872767857142857e-05 1.8 1.1877232142857143e-05 1.8
+ 1.1877790178571428e-05 0.0 1.1890066964285714e-05 0.0 1.1890625e-05 1.8 1.1895089285714285e-05 1.8 1.189564732142857e-05
+ 0.0 1.1907924107142857e-05 0.0 1.1908482142857142e-05 1.8 1.1912946428571427e-05 1.8
+ 1.1913504464285714e-05 0.0 1.1925781249999999e-05 0.0 1.1926339285714286e-05 1.8 1.1930803571428571e-05 1.8
+ 1.1931361607142856e-05 0.0 1.1943638392857141e-05 0.0 1.1944196428571428e-05 1.8 1.1948660714285714e-05 1.8
+ 1.1949218749999999e-05 0.0 1.1961495535714285e-05 0.0 1.196205357142857e-05 1.8 1.1966517857142856e-05 1.8
+ 1.1967075892857143e-05 0.0 1.1979352678571428e-05 0.0 1.1979910714285713e-05 1.8 1.1984375e-05 1.8 1.1984933035714285e-05
+ 0.0 1.199720982142857e-05 0.0 1.1997767857142857e-05 1.8 1.2002232142857142e-05 1.8
+ 1.2002790178571427e-05 0.0 1.2015066964285714e-05 0.0 1.2015624999999999e-05 1.8 1.2020089285714285e-05 1.8
+ 1.2020647321428571e-05 0.0 1.2032924107142856e-05 0.0 1.2033482142857141e-05 1.8 1.2037946428571427e-05 1.8
+ 1.2038504464285714e-05 0.0 1.2050781249999999e-05 0.0 1.2051339285714285e-05 1.8 1.2055803571428571e-05 1.8
+ 1.2056361607142856e-05 0.0 1.2068638392857143e-05 0.0 1.2069196428571428e-05 1.8 1.2073660714285713e-05 1.8
+ 1.2074218749999998e-05 0.0 1.2086495535714285e-05 0.0 1.208705357142857e-05 1.8 1.2091517857142856e-05 1.8
+ 1.2092075892857142e-05 0.0 1.2104352678571427e-05 0.0 1.2104910714285714e-05 1.8 1.2109375e-05 1.8 1.2109933035714285e-05
+ 0.0 1.2122209821428571e-05 0.0 1.2122767857142856e-05 1.8 1.2127232142857142e-05 1.8
+ 1.2127790178571427e-05 0.0 1.2140066964285714e-05 0.0 1.2140624999999999e-05 1.8 1.2145089285714284e-05 1.8
+ 1.2145647321428571e-05 0.0 1.2157924107142856e-05 0.0 1.2158482142857143e-05 1.8 1.2162946428571428e-05 1.8
+ 1.2163504464285713e-05 0.0 1.217578125e-05 0.0 1.2176339285714285e-05 1.8 1.218080357142857e-05 1.8 1.2181361607142856e-05
+ 0.0 1.2193638392857142e-05 0.0 1.2194196428571427e-05 1.8 1.2198660714285713e-05 1.8 1.219921875e-05
+ 0.0 1.2211495535714285e-05 0.0 1.2212053571428571e-05 1.8 1.2216517857142857e-05 1.8
+ 1.2217075892857142e-05 0.0 1.2229352678571427e-05 0.0 1.2229910714285714e-05 1.8 1.2234375e-05 1.8 1.2234933035714284e-05
+ 0.0 1.2247209821428571e-05 0.0 1.2247767857142856e-05 1.8 1.2252232142857142e-05 1.8
+ 1.2252790178571428e-05 0.0 1.2265066964285713e-05 0.0 1.2265624999999998e-05 1.8 1.2270089285714286e-05 1.8
+ 1.227064732142857e-05 0.0 1.2282924107142856e-05 0.0 1.2283482142857142e-05 1.8 1.2287946428571428e-05 1.8
+ 1.2288504464285713e-05 0.0 1.230078125e-05 0.0 1.2301339285714285e-05 1.8 1.230580357142857e-05 1.8 1.2306361607142857e-05
+ 0.0 1.2318638392857142e-05 0.0 1.2319196428571427e-05 1.8 1.2323660714285714e-05 1.8 1.232421875e-05
+ 0.0 1.2336495535714284e-05 0.0 1.2337053571428571e-05 1.8 1.2341517857142857e-05 1.8
+ 1.2342075892857142e-05 0.0 1.2354352678571428e-05 0.0 1.2354910714285713e-05 1.8 1.2359374999999999e-05 1.8
+ 1.2359933035714286e-05 0.0 1.237220982142857e-05 0.0 1.2372767857142856e-05 1.8 1.2377232142857141e-05 1.8
+ 1.2377790178571428e-05 0.0 1.2390066964285713e-05 0.0 1.2390625e-05 1.8 1.2395089285714285e-05 1.8 1.239564732142857e-05
+ 0.0 1.2407924107142857e-05 0.0 1.2408482142857142e-05 1.8 1.2412946428571428e-05 1.8
+ 1.2413504464285713e-05 0.0 1.242578125e-05 0.0 1.2426339285714284e-05 1.8 1.243080357142857e-05 1.8 1.2431361607142857e-05
+ 0.0 1.2443638392857142e-05 0.0 1.2444196428571428e-05 1.8 1.2448660714285714e-05 1.8
+ 1.2449218749999999e-05 0.0 1.2461495535714286e-05 0.0 1.246205357142857e-05 1.8 1.2466517857142856e-05 1.8
+ 1.2467075892857141e-05 0.0 1.2479352678571428e-05 0.0 1.2479910714285713e-05 1.8 1.2484374999999999e-05 1.8
+ 1.2484933035714285e-05 0.0 1.249720982142857e-05 0.0 1.2497767857142857e-05 1.8 1.2502232142857143e-05 1.8
+ 1.2502790178571428e-05 0.0 1.2515066964285714e-05 0.0 1.2515625e-05 1.8 1.2520089285714285e-05 1.8 1.252064732142857e-05
+ 0.0 1.2532924107142857e-05 0.0 1.2533482142857142e-05 1.8 1.2537946428571427e-05 1.8
+ 1.2538504464285714e-05 0.0 1.2550781249999999e-05 0.0 1.2551339285714286e-05 1.8 1.2555803571428571e-05 1.8
+ 1.2556361607142856e-05 0.0 1.2568638392857141e-05 0.0 1.2569196428571428e-05 1.8 1.2573660714285714e-05 1.8
+ 1.2574218749999999e-05 0.0 1.2586495535714285e-05 0.0 1.258705357142857e-05 1.8 1.2591517857142856e-05 1.8
+ 1.2592075892857143e-05 0.0 1.2604352678571428e-05 0.0 1.2604910714285713e-05 1.8 1.2609375e-05 1.8 1.2609933035714285e-05
+ 0.0 1.262220982142857e-05 0.0 1.2622767857142857e-05 1.8 1.2627232142857142e-05 1.8
+ 1.2627790178571427e-05 0.0 1.2640066964285714e-05 0.0 1.2640624999999999e-05 1.8 1.2645089285714285e-05 1.8
+ 1.2645647321428571e-05 0.0 1.2657924107142856e-05 0.0 1.2658482142857141e-05 1.8 1.2662946428571427e-05 1.8
+ 1.2663504464285714e-05 0.0 1.2675781249999999e-05 0.0 1.2676339285714285e-05 1.8 1.2680803571428571e-05 1.8
+ 1.2681361607142856e-05 0.0 1.2693638392857143e-05 0.0 1.2694196428571428e-05 1.8 1.2698660714285713e-05 1.8
+ 1.269921875e-05 0.0 1.2711495535714285e-05 0.0 1.271205357142857e-05 1.8 1.2716517857142856e-05 1.8
+ 1.2717075892857142e-05 0.0 1.2729352678571427e-05 0.0 1.2729910714285714e-05 1.8 1.2734375e-05 1.8 1.2734933035714285e-05
+ 0.0 1.2747209821428571e-05 0.0 1.2747767857142856e-05 1.8 1.2752232142857142e-05 1.8
+ 1.2752790178571427e-05 0.0 1.2765066964285714e-05 0.0 1.2765624999999999e-05 1.8 1.2770089285714284e-05 1.8
+ 1.2770647321428571e-05 0.0 1.2782924107142856e-05 0.0 1.2783482142857143e-05 1.8 1.2787946428571428e-05 1.8
+ 1.2788504464285713e-05 0.0 1.280078125e-05 0.0 1.2801339285714285e-05 1.8 1.280580357142857e-05 1.8 1.2806361607142856e-05
+ 0.0 1.2818638392857142e-05 0.0 1.2819196428571427e-05 1.8 1.2823660714285713e-05 1.8 1.282421875e-05
+ 0.0 1.2836495535714285e-05 0.0 1.2837053571428571e-05 1.8 1.2841517857142857e-05 1.8
+ 1.2842075892857142e-05 0.0 1.2854352678571427e-05 0.0 1.2854910714285714e-05 1.8 1.2859375e-05 1.8 1.2859933035714284e-05
+ 0.0 1.2872209821428571e-05 0.0 1.2872767857142856e-05 1.8 1.2877232142857141e-05 1.8
+ 1.2877790178571428e-05 0.0 1.2890066964285713e-05 0.0 1.2890624999999998e-05 1.8 1.2895089285714286e-05 1.8
+ 1.289564732142857e-05 0.0 1.2907924107142855e-05 0.0 1.2908482142857142e-05 1.8 1.2912946428571428e-05 1.8
+ 1.2913504464285713e-05 0.0 1.2925223214285713e-05 0.0 1.292578125e-05 1.8 1.2931361607142857e-05 1.8
+ 1.2931919642857142e-05 0.0 1.2943080357142857e-05 0.0 1.2943638392857142e-05 1.8 1.294921875e-05 1.8
+ 1.2949776785714284e-05 0.0 1.2960937499999999e-05 0.0 1.2961495535714284e-05 1.8 1.2967075892857142e-05 1.8
+ 1.2967633928571428e-05 0.0 1.2978794642857141e-05 0.0 1.2979352678571428e-05 1.8 1.2984933035714286e-05 1.8
+ 1.298549107142857e-05 0.0 1.2996651785714285e-05 0.0 1.299720982142857e-05 1.8 1.3002790178571428e-05 1.8
+ 1.3003348214285713e-05 0.0 1.3014508928571428e-05 0.0 1.3015066964285713e-05 1.8 1.302064732142857e-05 1.8
+ 1.3021205357142857e-05 0.0 1.303236607142857e-05 0.0 1.3032924107142857e-05 1.8 1.3038504464285713e-05 1.8 1.30390625e-05
+ 0.0 1.3050223214285714e-05 0.0 1.305078125e-05 1.8 1.3056361607142857e-05 1.8 1.3056919642857142e-05
+ 0.0 1.3068080357142856e-05 0.0 1.3068638392857141e-05 1.8 1.3074218749999999e-05 1.8
+ 1.3074776785714284e-05 0.0 1.3085937499999999e-05 0.0 1.3086495535714286e-05 1.8 1.3092075892857141e-05 1.8
+ 1.3092633928571428e-05 0.0 1.3103794642857141e-05 0.0 1.3104352678571428e-05 1.8 1.3109933035714285e-05 1.8
+ 1.311049107142857e-05 0.0 1.3121651785714285e-05 0.0 1.312220982142857e-05 1.8 1.3127790178571428e-05 1.8
+ 1.3128348214285713e-05 0.0 1.3139508928571427e-05 0.0 1.3140066964285714e-05 1.8 1.314564732142857e-05 1.8
+ 1.3146205357142857e-05 0.0 1.315736607142857e-05 0.0 1.3157924107142856e-05 1.8 1.3163504464285714e-05 1.8
+ 1.3164062499999999e-05 0.0 1.3175223214285714e-05 0.0 1.3175781249999999e-05 1.8 1.3181361607142856e-05 1.8
+ 1.3181919642857141e-05 0.0 1.3193080357142856e-05 0.0 1.3193638392857141e-05 1.8 1.3199218749999999e-05 1.8
+ 1.3199776785714285e-05 0.0 1.3210937499999998e-05 0.0 1.3211495535714285e-05 1.8 1.3217075892857143e-05 1.8
+ 1.3217633928571428e-05 0.0 1.3228794642857142e-05 0.0 1.3229352678571427e-05 1.8 1.3234933035714285e-05 1.8
+ 1.323549107142857e-05 0.0 1.3246651785714285e-05 0.0 1.324720982142857e-05 1.8 1.3252790178571427e-05 1.8
+ 1.3253348214285714e-05 0.0 1.3264508928571427e-05 0.0 1.3265066964285714e-05 1.8 1.3270647321428571e-05 1.8
+ 1.3271205357142856e-05 0.0 1.3282366071428571e-05 0.0 1.3282924107142856e-05 1.8 1.3288504464285714e-05 1.8
+ 1.3289062499999999e-05 0.0 1.3300223214285713e-05 0.0 1.3300781249999998e-05 1.8 1.3306361607142856e-05 1.8
+ 1.3306919642857143e-05 0.0 1.3318080357142856e-05 0.0 1.3318638392857142e-05 1.8 1.332421875e-05 1.8
+ 1.3324776785714285e-05 0.0 1.3335379464285713e-05 0.0 1.33359375e-05 1.8 1.3342633928571427e-05 1.8 1.3343191964285714e-05
+ 0.0 1.3353236607142857e-05 0.0 1.3353794642857142e-05 1.8 1.3360491071428571e-05 1.8
+ 1.3361049107142856e-05 0.0 1.337109375e-05 0.0 1.3371651785714284e-05 1.8 1.3378348214285714e-05 1.8
+ 1.3378906249999999e-05 0.0 1.3388950892857142e-05 0.0 1.3389508928571428e-05 1.8 1.3396205357142856e-05 1.8
+ 1.3396763392857143e-05 0.0 1.3406808035714284e-05 0.0 1.340736607142857e-05 1.8 1.3414062499999998e-05 1.8
+ 1.3414620535714285e-05 0.0 1.3424665178571428e-05 0.0 1.3425223214285713e-05 1.8 1.3431919642857142e-05 1.8
+ 1.3432477678571427e-05 0.0 1.344252232142857e-05 0.0 1.3443080357142855e-05 1.8 1.3449776785714285e-05 1.8
+ 1.345033482142857e-05 0.0 1.3460379464285713e-05 0.0 1.34609375e-05 1.8 1.3467633928571427e-05 1.8 1.3468191964285714e-05
+ 0.0 1.3478236607142857e-05 0.0 1.3478794642857142e-05 1.8 1.3485491071428571e-05 1.8
+ 1.3486049107142856e-05 0.0 1.3496093749999999e-05 0.0 1.3496651785714284e-05 1.8 1.3503348214285713e-05 1.8
+ 1.3503906249999998e-05 0.0 1.3513950892857141e-05 0.0 1.3514508928571428e-05 1.8 1.3521205357142856e-05 1.8
+ 1.3521763392857142e-05 0.0 1.3531808035714285e-05 0.0 1.353236607142857e-05 1.8 1.35390625e-05 1.8 1.3539620535714285e-05
+ 0.0 1.3549665178571428e-05 0.0 1.3550223214285713e-05 1.8 1.3556919642857142e-05 1.8
+ 1.3557477678571427e-05 0.0 1.356752232142857e-05 0.0 1.3568080357142857e-05 1.8 1.3574776785714284e-05 1.8
+ 1.3575334821428571e-05 0.0 1.3585379464285714e-05 0.0 1.3585937499999999e-05 1.8 1.3592633928571428e-05 1.8
+ 1.3593191964285713e-05 0.0 1.3603236607142856e-05 0.0 1.3603794642857141e-05 1.8 1.361049107142857e-05 1.8
+ 1.3611049107142856e-05 0.0 1.3621093749999999e-05 0.0 1.3621651785714285e-05 1.8 1.3628348214285713e-05 1.8
+ 1.362890625e-05 0.0 1.3638950892857143e-05 0.0 1.3639508928571428e-05 1.8 1.3646205357142857e-05 1.8
+ 1.3646763392857142e-05 0.0 1.3656808035714285e-05 0.0 1.365736607142857e-05 1.8 1.36640625e-05 1.8 1.3664620535714284e-05
+ 0.0 1.3674665178571427e-05 0.0 1.3675223214285714e-05 1.8 1.3682477678571428e-05 1.8
+ 1.3683035714285713e-05 0.0 1.3691964285714285e-05 0.0 1.369252232142857e-05 1.8 1.370033482142857e-05 1.8
+ 1.3700892857142856e-05 0.0 1.3709821428571427e-05 0.0 1.3710379464285714e-05 1.8 1.3718191964285713e-05 1.8 1.371875e-05
+ 0.0 1.3727678571428571e-05 0.0 1.3728236607142856e-05 1.8 1.3736049107142857e-05 1.8
+ 1.3736607142857142e-05 0.0 1.3745535714285713e-05 0.0 1.3746093749999998e-05 1.8 1.375390625e-05 1.8
+ 1.3754464285714284e-05 0.0 1.3763392857142856e-05 0.0 1.3763950892857142e-05 1.8 1.3771763392857142e-05 1.8
+ 1.3772321428571428e-05 0.0 1.378125e-05 0.0 1.3781808035714285e-05 1.8 1.3789620535714284e-05 1.8 1.379017857142857e-05
+ 0.0 1.3799107142857142e-05 0.0 1.3799665178571427e-05 1.8 1.3807477678571428e-05 1.8
+ 1.3808035714285713e-05 0.0 1.3816964285714284e-05 0.0 1.3817522321428571e-05 1.8 1.382533482142857e-05 1.8
+ 1.3825892857142855e-05 0.0 1.3834821428571428e-05 0.0 1.3835379464285713e-05 1.8 1.3843191964285713e-05 1.8 1.384375e-05
+ 0.0 1.385267857142857e-05 0.0 1.3853236607142856e-05 1.8 1.3861049107142857e-05 1.8
+ 1.3861607142857142e-05 0.0 1.3870535714285713e-05 0.0 1.387109375e-05 1.8 1.3878906249999999e-05 1.8
+ 1.3879464285714284e-05 0.0 1.3888392857142857e-05 0.0 1.3888950892857142e-05 1.8 1.3896763392857141e-05 1.8
+ 1.3897321428571428e-05 0.0 1.390625e-05 0.0 1.3906808035714284e-05 1.8 1.3914620535714285e-05 1.8 1.391517857142857e-05
+ 0.0 1.3924107142857142e-05 0.0 1.3924665178571428e-05 1.8 1.3932477678571428e-05 1.8
+ 1.3933035714285713e-05 0.0 1.3941964285714286e-05 0.0 1.394252232142857e-05 1.8 1.395033482142857e-05 1.8
+ 1.3950892857142857e-05 0.0 1.3959821428571428e-05 0.0 1.3960379464285713e-05 1.8 1.3968191964285714e-05 1.8
+ 1.3968749999999999e-05 0.0 1.397767857142857e-05 0.0 1.3978236607142857e-05 1.8 1.3986049107142856e-05 1.8
+ 1.3986607142857141e-05 0.0 1.3995535714285713e-05 0.0 1.399609375e-05 1.8 1.4004464285714285e-05 1.8 1.400502232142857e-05
+ 0.0 1.401283482142857e-05 0.0 1.4013392857142857e-05 1.8 1.4022321428571428e-05 1.8
+ 1.4022879464285713e-05 0.0 1.4030691964285714e-05 0.0 1.4031249999999999e-05 1.8 1.404017857142857e-05 1.8
+ 1.4040736607142857e-05 0.0 1.4048549107142856e-05 0.0 1.4049107142857141e-05 1.8 1.4058035714285714e-05 1.8
+ 1.4058593749999999e-05 0.0 1.4066406249999998e-05 0.0 1.4066964285714285e-05 1.8 1.4075892857142856e-05 1.8
+ 1.4076450892857141e-05 0.0 1.4084263392857142e-05 0.0 1.4084821428571428e-05 1.8 1.4093749999999999e-05 1.8
+ 1.4094308035714285e-05 0.0 1.4102120535714285e-05 0.0 1.410267857142857e-05 1.8 1.4111607142857141e-05 1.8
+ 1.4112165178571428e-05 0.0 1.4119977678571427e-05 0.0 1.4120535714285714e-05 1.8 1.4129464285714285e-05 1.8
+ 1.413002232142857e-05 0.0 1.4137834821428571e-05 0.0 1.4138392857142856e-05 1.8 1.4147321428571427e-05 1.8
+ 1.4147879464285714e-05 0.0 1.4155691964285713e-05 0.0 1.4156249999999999e-05 1.8 1.416517857142857e-05 1.8
+ 1.4165736607142856e-05 0.0 1.4173549107142856e-05 0.0 1.4174107142857143e-05 1.8 1.4183035714285714e-05 1.8
+ 1.4183593749999999e-05 0.0 1.419140625e-05 0.0 1.4191964285714285e-05 1.8 1.4200892857142856e-05 1.8
+ 1.4201450892857141e-05 0.0 1.4209263392857142e-05 0.0 1.4209821428571427e-05 1.8 1.4218749999999998e-05 1.8
+ 1.4219308035714285e-05 0.0 1.4227120535714284e-05 0.0 1.4227678571428571e-05 1.8 1.4236607142857142e-05 1.8
+ 1.4237165178571427e-05 0.0 1.4244977678571427e-05 0.0 1.4245535714285714e-05 1.8 1.4254464285714285e-05 1.8
+ 1.425502232142857e-05 0.0 1.426283482142857e-05 0.0 1.4263392857142856e-05 1.8 1.4272321428571427e-05 1.8
+ 1.4272879464285714e-05 0.0 1.4280691964285713e-05 0.0 1.4281249999999998e-05 1.8 1.4290178571428571e-05 1.8
+ 1.4290736607142856e-05 0.0 1.4298549107142855e-05 0.0 1.4299107142857142e-05 1.8 1.4308035714285713e-05 1.8
+ 1.4308593749999998e-05 0.0 1.431640625e-05 0.0 1.4316964285714284e-05 1.8 1.4326450892857142e-05 1.8
+ 1.4327008928571427e-05 0.0 1.4333705357142857e-05 0.0 1.4334263392857142e-05 1.8 1.4344308035714285e-05 1.8
+ 1.434486607142857e-05 0.0 1.4351562499999999e-05 0.0 1.4352120535714284e-05 1.8 1.4362165178571427e-05 1.8
+ 1.4362723214285714e-05 0.0 1.4369419642857141e-05 0.0 1.4369977678571428e-05 1.8 1.4380022321428571e-05 1.8
+ 1.4380580357142856e-05 0.0 1.4387276785714285e-05 0.0 1.438783482142857e-05 1.8 1.4397879464285713e-05 1.8
+ 1.4398437499999998e-05 0.0 1.4405133928571428e-05 0.0 1.4405691964285713e-05 1.8 1.4415736607142856e-05 1.8
+ 1.4416294642857142e-05 0.0 1.442299107142857e-05 0.0 1.4423549107142857e-05 1.8 1.443359375e-05 1.8 1.4434151785714285e-05
+ 0.0 1.4440848214285714e-05 0.0 1.4441406249999999e-05 1.8 1.4451450892857142e-05 1.8
+ 1.4452008928571427e-05 0.0 1.4458705357142856e-05 0.0 1.4459263392857141e-05 1.8 1.4469308035714284e-05 1.8
+ 1.4469866071428571e-05 0.0 1.4476562499999999e-05 0.0 1.4477120535714285e-05 1.8 1.4487165178571427e-05 1.8
+ 1.4487723214285713e-05 0.0 1.4494419642857141e-05 0.0 1.4494977678571428e-05 1.8 1.450502232142857e-05 1.8
+ 1.4505580357142856e-05 0.0 1.4512276785714285e-05 0.0 1.451283482142857e-05 1.8 1.4522879464285713e-05 1.8
+ 1.4523437499999998e-05 0.0 1.4530133928571427e-05 0.0 1.4530691964285714e-05 1.8 1.4540736607142855e-05 1.8
+ 1.4541294642857142e-05 0.0 1.454799107142857e-05 0.0 1.4548549107142856e-05 1.8 1.455859375e-05 1.8 1.4559151785714284e-05
+ 0.0 1.4565848214285714e-05 0.0 1.4566406249999999e-05 1.8 1.4576450892857142e-05 1.8
+ 1.4577008928571427e-05 0.0 1.4583705357142856e-05 0.0 1.4584263392857141e-05 1.8 1.4594308035714284e-05 1.8
+ 1.459486607142857e-05 0.0 1.4601562499999998e-05 0.0 1.4602120535714285e-05 1.8 1.4612165178571428e-05 1.8
+ 1.4612723214285713e-05 0.0 1.4619419642857142e-05 0.0 1.4619977678571427e-05 1.8 1.463002232142857e-05 1.8
+ 1.4630580357142855e-05 0.0 1.4637276785714285e-05 0.0 1.463783482142857e-05 1.8 1.4647879464285713e-05 1.8 1.46484375e-05
+ 0.0 1.4655133928571427e-05 0.0 1.4655691964285714e-05 1.8 1.4665736607142857e-05 1.8
+ 1.4666294642857142e-05 0.0 1.4672433035714284e-05 0.0 1.4672991071428571e-05 1.8 1.4684151785714284e-05 1.8
+ 1.4684709821428571e-05 0.0 1.4690290178571428e-05 0.0 1.4690848214285713e-05 1.8 1.4702008928571428e-05 1.8
+ 1.4702566964285713e-05 0.0 1.470814732142857e-05 0.0 1.4708705357142856e-05 1.8 1.471986607142857e-05 1.8
+ 1.4720424107142856e-05 0.0 1.4726004464285713e-05 0.0 1.47265625e-05 1.8 1.4737723214285713e-05 1.8 1.473828125e-05 0.0
+ 1.4743861607142857e-05 0.0 1.4744419642857142e-05 1.8 1.4755580357142857e-05 1.8 1.4756138392857142e-05 0.0
+ 1.476171875e-05 0.0 1.4762276785714284e-05 1.8 1.4773437499999999e-05 1.8 1.4773995535714284e-05 0.0
+ 1.4779575892857142e-05 0.0 1.4780133928571428e-05 1.8 1.4791294642857141e-05 1.8 1.4791852678571428e-05 0.0
+ 1.4797433035714284e-05 0.0 1.479799107142857e-05 1.8 1.4809151785714285e-05 1.8 1.480970982142857e-05 0.0
+ 1.4815290178571428e-05 0.0 1.4815848214285713e-05 1.8 1.4827008928571428e-05 1.8 1.4827566964285713e-05 0.0
+ 1.483314732142857e-05 0.0 1.4833705357142855e-05 1.8 1.484486607142857e-05 1.8 1.4845424107142857e-05 0.0
+ 1.4851004464285713e-05 0.0 1.48515625e-05 1.8 1.4862723214285712e-05 1.8 1.486328125e-05 0.0 1.4868861607142857e-05 0.0
+ 1.4869419642857142e-05 1.8 1.4880580357142856e-05 1.8 1.4881138392857141e-05 0.0 1.4886718749999999e-05 0.0
+ 1.4887276785714284e-05 1.8 1.4898437499999999e-05 1.8 1.4898995535714284e-05 0.0 1.4904575892857141e-05 0.0
+ 1.4905133928571428e-05 1.8 1.4916294642857141e-05 1.8 1.4916852678571428e-05 0.0 1.4922433035714285e-05 0.0
+ 1.492299107142857e-05 1.8 1.4934151785714285e-05 1.8 1.493470982142857e-05 0.0 1.4940290178571428e-05 0.0
+ 1.4940848214285713e-05 1.8 1.4952008928571427e-05 1.8 1.4952566964285712e-05 0.0 1.495814732142857e-05 0.0
+ 1.4958705357142857e-05 1.8 1.496986607142857e-05 1.8 1.4970424107142857e-05 0.0 1.4976004464285714e-05 0.0
+ 1.4976562499999999e-05 1.8 1.4987723214285714e-05 1.8 1.4988281249999999e-05 0.0 1.4993861607142856e-05 0.0
+ 1.4994419642857141e-05 1.8 1.5005580357142856e-05 1.8 1.5006138392857141e-05 0.0 1.5011718749999999e-05 0.0
+ 1.5012276785714285e-05 1.8 1.5023437499999998e-05 1.8 1.5023995535714285e-05 0.0 1.5029575892857143e-05 0.0
+ 1.5030133928571428e-05 1.8 1.5041294642857142e-05 1.8 1.5041852678571427e-05 0.0 1.5047433035714285e-05 0.0
+ 1.504799107142857e-05 1.8 1.5059151785714285e-05 1.8 1.505970982142857e-05 0.0 1.5065290178571427e-05 0.0
+ 1.5065848214285714e-05 1.8 1.5077008928571427e-05 1.8 1.5077566964285714e-05 0.0 1.5082589285714284e-05 0.0
+ 1.508314732142857e-05 1.8 1.5095424107142856e-05 1.8 1.5095982142857141e-05 0.0 1.5100446428571427e-05 0.0
+ 1.5101004464285714e-05 1.8 1.5113281249999998e-05 1.8 1.5113839285714285e-05 0.0 1.511830357142857e-05 0.0
+ 1.5118861607142856e-05 1.8 1.5131138392857142e-05 1.8 1.5131696428571428e-05 0.0 1.5136160714285713e-05 0.0
+ 1.5136718749999998e-05 1.8 1.5148995535714285e-05 1.8 1.514955357142857e-05 0.0 1.5154017857142855e-05 0.0
+ 1.5154575892857142e-05 1.8 1.5166852678571427e-05 1.8 1.5167410714285714e-05 0.0 1.5171875e-05 0.0 1.5172433035714285e-05
+ 1.8 1.5184709821428571e-05 1.8 1.5185267857142856e-05 0.0 1.5189732142857142e-05 0.0
+ 1.5190290178571427e-05 1.8 1.5202566964285713e-05 1.8 1.5203124999999999e-05 0.0 1.5207589285714284e-05 0.0
+ 1.5208147321428571e-05 1.8 1.5220424107142856e-05 1.8 1.5220982142857143e-05 0.0 1.5225446428571428e-05 0.0
+ 1.5226004464285713e-05 1.8 1.5238281249999998e-05 1.8 1.5238839285714285e-05 0.0 1.524330357142857e-05 0.0
+ 1.5243861607142856e-05 1.8 1.5256138392857142e-05 1.8 1.5256696428571427e-05 0.0 1.5261160714285713e-05 0.0
+ 1.526171875e-05 1.8 1.5273995535714284e-05 1.8 1.527455357142857e-05 0.0 1.5279017857142855e-05 0.0
+ 1.5279575892857142e-05 1.8 1.5291852678571427e-05 1.8 1.5292410714285714e-05 0.0 1.5296874999999997e-05 0.0
+ 1.5297433035714284e-05 1.8 1.530970982142857e-05 1.8 1.5310267857142856e-05 0.0 1.5314732142857143e-05 0.0
+ 1.5315290178571427e-05 1.8 1.5327566964285715e-05 1.8 1.5328124999999998e-05 0.0 1.5332589285714285e-05 0.0
+ 1.533314732142857e-05 1.8 1.5345424107142857e-05 1.8 1.534598214285714e-05 0.0 1.5350446428571428e-05 0.0
+ 1.5351004464285715e-05 1.8 1.536328125e-05 1.8 1.5363839285714286e-05 0.0 1.536830357142857e-05 0.0 1.5368861607142857e-05
+ 1.8 1.5381138392857142e-05 1.8 1.538169642857143e-05 0.0 1.5386160714285712e-05 0.0 1.538671875e-05 1.8
+ 1.5398995535714284e-05 1.8 1.539955357142857e-05 0.0 1.5404017857142855e-05 0.0 1.540457589285714e-05 1.8
+ 1.5416852678571426e-05 1.8 1.5417410714285713e-05 0.0 1.5421875e-05 0.0 1.5422433035714284e-05 1.8 1.543470982142857e-05
+ 1.8 1.5435267857142856e-05 0.0 1.5439732142857143e-05 0.0 1.5440290178571426e-05 1.8
+ 1.5452566964285714e-05 1.8 1.5453124999999998e-05 0.0 1.5457589285714285e-05 0.0 1.5458147321428572e-05 1.8
+ 1.5470424107142857e-05 1.8 1.547098214285714e-05 0.0 1.5475446428571427e-05 0.0 1.5476004464285714e-05 1.8 1.548828125e-05
+ 1.8 1.5488839285714286e-05 0.0 1.549330357142857e-05 0.0 1.5493861607142857e-05 1.8
+ 1.550613839285714e-05 1.8 1.5506696428571428e-05 0.0 1.5511160714285712e-05 0.0 1.551171875e-05 1.8
+ 1.5523995535714284e-05 1.8 1.552455357142857e-05 0.0 1.5529017857142854e-05 0.0 1.552957589285714e-05 1.8
+ 1.5541852678571426e-05 1.8 1.5542410714285713e-05 0.0 1.5546875e-05 0.0 1.5547433035714283e-05 1.8 1.5559709821428572e-05
+ 1.8 1.5560267857142855e-05 0.0 1.5564732142857142e-05 0.0 1.5565290178571426e-05 1.8
+ 1.5577566964285714e-05 1.8 1.5578124999999997e-05 0.0 1.5582589285714285e-05 0.0 1.558314732142857e-05 1.8
+ 1.5595424107142856e-05 1.8 1.5595982142857143e-05 0.0 1.5600446428571427e-05 0.0 1.5601004464285714e-05 1.8
+ 1.561328125e-05 1.8 1.5613839285714286e-05 0.0 1.561830357142857e-05 0.0 1.5618861607142856e-05 1.8
+ 1.563113839285714e-05 1.8 1.5631696428571428e-05 0.0 1.5636160714285712e-05 0.0 1.563671875e-05 1.8
+ 1.5648995535714283e-05 1.8 1.564955357142857e-05 0.0 1.5654017857142857e-05 0.0 1.565457589285714e-05 1.8
+ 1.566685267857143e-05 1.8 1.5667410714285712e-05 0.0 1.5671875e-05 0.0 1.5672433035714283e-05 1.8 1.568470982142857e-05
+ 1.8 1.5685267857142855e-05 0.0 1.5689732142857142e-05 0.0 1.569029017857143e-05 1.8
+ 1.5702566964285714e-05 1.8 1.5703125e-05 0.0 1.5707589285714284e-05 0.0 1.570814732142857e-05 1.8 1.5720424107142856e-05
+ 1.8 1.5720982142857143e-05 0.0 1.5725446428571427e-05 0.0 1.5726004464285713e-05 1.8 1.573828125e-05
+ 1.8 1.5738839285714285e-05 0.0 1.574330357142857e-05 0.0 1.5743861607142856e-05 1.8
+ 1.575613839285714e-05 1.8 1.5756696428571427e-05 0.0 1.5761160714285715e-05 0.0 1.5761718749999998e-05 1.8
+ 1.5773995535714283e-05 1.8 1.577455357142857e-05 0.0 1.5779017857142857e-05 0.0 1.577957589285714e-05 1.8
+ 1.579185267857143e-05 1.8 1.5792410714285712e-05 0.0 1.5796875e-05 0.0 1.5797433035714286e-05 1.8 1.580970982142857e-05
+ 1.8 1.5810267857142854e-05 0.0 1.5814732142857142e-05 0.0 1.581529017857143e-05 1.8
+ 1.5827566964285713e-05 1.8 1.5828125e-05 0.0 1.5832589285714284e-05 0.0 1.583314732142857e-05 1.8 1.5845424107142856e-05
+ 1.8 1.5845982142857143e-05 0.0 1.5850446428571426e-05 0.0 1.5851004464285713e-05 1.8
+ 1.5863281249999998e-05 1.8 1.5863839285714285e-05 0.0 1.586830357142857e-05 0.0 1.5868861607142855e-05 1.8
+ 1.588113839285714e-05 1.8 1.5881696428571427e-05 0.0 1.5886160714285714e-05 0.0 1.5886718749999998e-05 1.8
+ 1.5898995535714286e-05 1.8 1.589955357142857e-05 0.0 1.5904017857142857e-05 0.0 1.590457589285714e-05 1.8
+ 1.591685267857143e-05 1.8 1.5917410714285712e-05 0.0 1.5921875e-05 0.0 1.5922433035714286e-05 1.8 1.593470982142857e-05
+ 1.8 1.5935267857142858e-05 0.0 1.593973214285714e-05 0.0 1.5940290178571428e-05 1.8
+ 1.5952566964285713e-05 1.8 1.5953125e-05 0.0 1.5957589285714284e-05 0.0 1.595814732142857e-05 1.8 1.5970424107142855e-05
+ 1.8 1.5970982142857142e-05 0.0 1.5975446428571426e-05 0.0 1.5976004464285713e-05 1.8
+ 1.5988281249999998e-05 1.8 1.5988839285714284e-05 0.0 1.5993303571428572e-05 0.0 1.5993861607142855e-05 1.8
+ 1.600613839285714e-05 1.8 1.6006696428571427e-05 0.0 1.6011160714285714e-05 0.0 1.6011718749999997e-05 1.8
+ 1.6023995535714286e-05 1.8 1.602455357142857e-05 0.0 1.6029017857142856e-05 0.0 1.6029575892857143e-05 1.8
+ 1.6041852678571428e-05 1.8 1.604241071428571e-05 0.0 1.6046875e-05 0.0 1.6047433035714285e-05 1.8 1.605970982142857e-05
+ 1.8 1.6060267857142857e-05 0.0 1.606473214285714e-05 0.0 1.6065290178571428e-05 1.8
+ 1.6077566964285713e-05 1.8 1.6078125e-05 0.0 1.6082589285714283e-05 0.0 1.608314732142857e-05 1.8 1.6095424107142855e-05
+ 1.8 1.6095982142857142e-05 0.0 1.610044642857143e-05 0.0 1.6101004464285712e-05 1.8
+ 1.6113281249999997e-05 1.8 1.6113839285714284e-05 0.0 1.611830357142857e-05 0.0 1.6118861607142855e-05 1.8
+ 1.6131138392857143e-05 1.8 1.6131696428571426e-05 0.0 1.6136160714285714e-05 0.0 1.613671875e-05 1.8
+ 1.6148995535714285e-05 1.8 1.614955357142857e-05 0.0 1.6154017857142856e-05 0.0 1.6154575892857143e-05 1.8
+ 1.6166852678571428e-05 1.8 1.6167410714285714e-05 0.0 1.6171875e-05 0.0 1.6172433035714285e-05 1.8 1.618470982142857e-05
+ 1.8 1.6185267857142857e-05 0.0 1.618973214285714e-05 0.0 1.6190290178571427e-05 1.8
+ 1.6202566964285712e-05 1.8 1.6203125e-05 0.0 1.6207589285714283e-05 0.0 1.620814732142857e-05 1.8 1.6220424107142855e-05
+ 1.8 1.622098214285714e-05 0.0 1.622544642857143e-05 0.0 1.6226004464285712e-05 1.8 1.623828125e-05 1.8
+ 1.6238839285714284e-05 0.0 1.624330357142857e-05 0.0 1.6243861607142854e-05 1.8 1.6256138392857143e-05 1.8
+ 1.6256696428571426e-05 0.0 1.6261160714285713e-05 0.0 1.626171875e-05 1.8 1.6273995535714285e-05 1.8
+ 1.6274553571428572e-05 0.0 1.6279017857142856e-05 0.0 1.6279575892857142e-05 1.8 1.6291852678571427e-05 1.8
+ 1.6292410714285714e-05 0.0 1.6296874999999998e-05 0.0 1.6297433035714285e-05 1.8 1.630970982142857e-05 1.8
+ 1.6310267857142856e-05 0.0 1.631473214285714e-05 0.0 1.6315290178571427e-05 1.8 1.6327566964285712e-05 1.8 1.6328125e-05
+ 0.0 1.6332589285714286e-05 0.0 1.633314732142857e-05 1.8 1.6345424107142854e-05 1.8
+ 1.634598214285714e-05 0.0 1.635044642857143e-05 0.0 1.6351004464285712e-05 1.8 1.636328125e-05 1.8 1.6363839285714283e-05
+ 0.0 1.636830357142857e-05 0.0 1.6368861607142857e-05 1.8 1.6381138392857142e-05 1.8
+ 1.6381696428571426e-05 0.0 1.6386160714285713e-05 0.0 1.638671875e-05 1.8 1.6398995535714285e-05 1.8 1.639955357142857e-05
+ 0.0 1.6404017857142855e-05 0.0 1.6404575892857142e-05 1.8 1.6416852678571427e-05 1.8
+ 1.6417410714285714e-05 0.0 1.6421874999999998e-05 0.0 1.6422433035714284e-05 1.8 1.643470982142857e-05 1.8
+ 1.6435267857142856e-05 0.0 1.643973214285714e-05 0.0 1.6440290178571427e-05 1.8 1.645256696428571e-05 1.8 1.6453125e-05
+ 0.0 1.6457589285714286e-05 0.0 1.645814732142857e-05 1.8 1.6470424107142857e-05 1.8
+ 1.647098214285714e-05 0.0 1.6475446428571428e-05 0.0 1.6476004464285715e-05 1.8 1.648828125e-05 1.8
+ 1.6488839285714283e-05 0.0 1.649330357142857e-05 0.0 1.6493861607142857e-05 1.8 1.6506138392857142e-05 1.8
+ 1.650669642857143e-05 0.0 1.6511160714285713e-05 0.0 1.651171875e-05 1.8 1.6523995535714284e-05 1.8 1.652455357142857e-05
+ 0.0 1.6529017857142855e-05 0.0 1.6529575892857142e-05 1.8 1.6541852678571427e-05 1.8
+ 1.6542410714285713e-05 0.0 1.6546874999999997e-05 0.0 1.6547433035714284e-05 1.8 1.655970982142857e-05 1.8
+ 1.6560267857142856e-05 0.0 1.6564732142857143e-05 0.0 1.6565290178571426e-05 1.8 1.6577566964285715e-05 1.8
+ 1.6578124999999998e-05 0.0 1.6582589285714285e-05 0.0 1.658314732142857e-05 1.8 1.6595424107142857e-05 1.8
+ 1.659598214285714e-05 0.0 1.6600446428571428e-05 0.0 1.6601004464285714e-05 1.8 1.661328125e-05 1.8
+ 1.6613839285714286e-05 0.0 1.661830357142857e-05 0.0 1.6618861607142857e-05 1.8 1.663113839285714e-05 1.8
+ 1.663169642857143e-05 0.0 1.6636160714285712e-05 0.0 1.663671875e-05 1.8 1.6648995535714284e-05 1.8 1.664955357142857e-05
+ 0.0 1.6654017857142855e-05 0.0 1.665457589285714e-05 1.8 1.6666852678571426e-05 1.8
+ 1.6667410714285713e-05 0.0 1.6671875e-05 0.0 1.6672433035714284e-05 1.8 1.668470982142857e-05 1.8 1.6685267857142855e-05
+ 0.0 1.6689732142857143e-05 0.0 1.6690290178571426e-05 1.8 1.6702566964285714e-05 1.8
+ 1.6703124999999998e-05 0.0 1.6707589285714285e-05 0.0 1.6708147321428572e-05 1.8 1.6720424107142857e-05 1.8
+ 1.672098214285714e-05 0.0 1.6725446428571427e-05 0.0 1.6726004464285714e-05 1.8 1.673828125e-05 1.8
+ 1.6738839285714286e-05 0.0 1.674330357142857e-05 0.0 1.6743861607142856e-05 1.8 1.675613839285714e-05 1.8
+ 1.6756696428571428e-05 0.0 1.6761160714285712e-05 0.0 1.676171875e-05 1.8 1.6773995535714284e-05 1.8 1.677455357142857e-05
+ 0.0 1.6779017857142854e-05 0.0 1.677957589285714e-05 1.8 1.6791852678571426e-05 1.8
+ 1.6792410714285713e-05 0.0 1.6796875e-05 0.0 1.6797433035714283e-05 1.8 1.680970982142857e-05 1.8 1.6810267857142855e-05
+ 0.0 1.6814732142857142e-05 0.0 1.6815290178571426e-05 1.8 1.6827566964285714e-05 1.8
+ 1.6828124999999997e-05 0.0 1.6832589285714285e-05 0.0 1.683314732142857e-05 1.8 1.6845424107142856e-05 1.8
+ 1.6845982142857143e-05 0.0 1.6850446428571427e-05 0.0 1.6851004464285714e-05 1.8 1.686328125e-05 1.8
+ 1.6863839285714285e-05 0.0 1.686830357142857e-05 0.0 1.6868861607142856e-05 1.8 1.688113839285714e-05 1.8
+ 1.6881696428571428e-05 0.0 1.688616071428571e-05 0.0 1.688671875e-05 1.8 1.6898995535714283e-05 1.8 1.689955357142857e-05
+ 0.0 1.6904017857142857e-05 0.0 1.690457589285714e-05 1.8 1.691685267857143e-05 1.8
+ 1.6917410714285712e-05 0.0 1.6922433035714283e-05 0.0 1.692299107142857e-05 1.8 1.6934151785714285e-05 1.8
+ 1.693470982142857e-05 0.0 1.694029017857143e-05 0.0 1.6940848214285712e-05 1.8 1.6952008928571427e-05 1.8
+ 1.6952566964285714e-05 0.0 1.695814732142857e-05 0.0 1.6958705357142854e-05 1.8 1.696986607142857e-05 1.8
+ 1.6970424107142856e-05 0.0 1.6976004464285713e-05 0.0 1.69765625e-05 1.8 1.698772321428571e-05 1.8 1.698828125e-05 0.0
+ 1.6993861607142856e-05 0.0 1.6994419642857142e-05 1.8 1.7005580357142857e-05 1.8 1.700613839285714e-05 0.0
+ 1.7011718749999998e-05 0.0 1.7012276785714285e-05 1.8 1.70234375e-05 1.8 1.7023995535714283e-05 0.0 1.702957589285714e-05
+ 0.0 1.7030133928571427e-05 1.8 1.7041294642857142e-05 1.8 1.704185267857143e-05 0.0
+ 1.7047433035714286e-05 0.0 1.704799107142857e-05 1.8 1.7059151785714284e-05 1.8 1.705970982142857e-05 0.0
+ 1.706529017857143e-05 0.0 1.7065848214285712e-05 1.8 1.7077008928571427e-05 1.8 1.7077566964285713e-05 0.0
+ 1.708314732142857e-05 0.0 1.7083705357142857e-05 1.8 1.709486607142857e-05 1.8 1.7095424107142856e-05 0.0
+ 1.7101004464285713e-05 0.0 1.71015625e-05 1.8 1.7112723214285715e-05 1.8 1.7113281249999998e-05 0.0 1.7118861607142855e-05
+ 0.0 1.7119419642857142e-05 1.8 1.7130580357142857e-05 1.8 1.713113839285714e-05 0.0
+ 1.7136718749999998e-05 0.0 1.7137276785714284e-05 1.8 1.71484375e-05 1.8 1.7148995535714286e-05 0.0 1.715457589285714e-05
+ 0.0 1.7155133928571427e-05 1.8 1.716629464285714e-05 1.8 1.716685267857143e-05 0.0
+ 1.7172433035714286e-05 0.0 1.717299107142857e-05 1.8 1.7184151785714284e-05 1.8 1.718470982142857e-05 0.0
+ 1.7190290178571428e-05 0.0 1.719084821428571e-05 1.8 1.7202008928571426e-05 1.8 1.7202566964285713e-05 0.0
+ 1.720814732142857e-05 0.0 1.7208705357142857e-05 1.8 1.721986607142857e-05 1.8 1.7220424107142855e-05 0.0
+ 1.7226004464285713e-05 0.0 1.72265625e-05 1.8 1.7237723214285714e-05 1.8 1.7238281249999998e-05 0.0 1.7243861607142855e-05
+ 0.0 1.7244419642857142e-05 1.8 1.7255580357142857e-05 1.8 1.725613839285714e-05 0.0
+ 1.7261718749999997e-05 0.0 1.7262276785714284e-05 1.8 1.72734375e-05 1.8 1.7273995535714286e-05 0.0 1.7279575892857143e-05
+ 0.0 1.7280133928571426e-05 1.8 1.729129464285714e-05 1.8 1.7291852678571428e-05 0.0
+ 1.7297433035714285e-05 0.0 1.729799107142857e-05 1.8 1.7309151785714284e-05 1.8 1.730970982142857e-05 0.0
+ 1.7315290178571428e-05 0.0 1.7315848214285714e-05 1.8 1.7327008928571426e-05 1.8 1.7327566964285713e-05 0.0
+ 1.7333705357142857e-05 0.0 1.733426339285714e-05 1.8 1.7344308035714285e-05 1.8 1.734486607142857e-05 0.0 1.73515625e-05
+ 0.0 1.7352120535714286e-05 1.8 1.7362165178571427e-05 1.8 1.7362723214285714e-05 0.0
+ 1.736941964285714e-05 0.0 1.7369977678571428e-05 1.8 1.738002232142857e-05 1.8 1.7380580357142856e-05 0.0
+ 1.7387276785714284e-05 0.0 1.738783482142857e-05 1.8 1.7397879464285712e-05 1.8 1.73984375e-05 0.0 1.7405133928571426e-05
+ 0.0 1.7405691964285713e-05 1.8 1.7415736607142857e-05 1.8 1.741629464285714e-05 0.0
+ 1.7422991071428572e-05 0.0 1.7423549107142855e-05 1.8 1.743359375e-05 1.8 1.7434151785714283e-05 0.0
+ 1.7440848214285714e-05 0.0 1.7441406249999997e-05 1.8 1.7451450892857142e-05 1.8 1.745200892857143e-05 0.0
+ 1.7458705357142856e-05 0.0 1.7459263392857143e-05 1.8 1.7469308035714284e-05 1.8 1.746986607142857e-05 0.0 1.74765625e-05
+ 0.0 1.7477120535714286e-05 1.8 1.7487165178571427e-05 1.8 1.7487723214285714e-05 0.0
+ 1.749441964285714e-05 0.0 1.7494977678571428e-05 1.8 1.750502232142857e-05 1.8 1.7505580357142856e-05 0.0
+ 1.7512276785714283e-05 0.0 1.751283482142857e-05 1.8 1.752287946428571e-05 1.8 1.7523437499999998e-05 0.0
+ 1.7530133928571426e-05 0.0 1.7530691964285712e-05 1.8 1.7540736607142857e-05 1.8 1.754129464285714e-05 0.0
+ 1.754799107142857e-05 0.0 1.7548549107142855e-05 1.8 1.755859375e-05 1.8 1.7559151785714283e-05 0.0
+ 1.7565848214285714e-05 0.0 1.7566406249999997e-05 1.8 1.7576450892857142e-05 1.8 1.757700892857143e-05 0.0
+ 1.7583705357142856e-05 0.0 1.7584263392857143e-05 1.8 1.7594308035714284e-05 1.8 1.759486607142857e-05 0.0 1.76015625e-05
+ 0.0 1.7602120535714285e-05 1.8 1.7612165178571426e-05 1.8 1.7612723214285713e-05 0.0
+ 1.761941964285714e-05 0.0 1.7619977678571427e-05 1.8 1.763002232142857e-05 1.8 1.7630580357142856e-05 0.0
+ 1.7637276785714283e-05 0.0 1.763783482142857e-05 1.8 1.7647879464285714e-05 1.8 1.7648437499999998e-05 0.0
+ 1.765513392857143e-05 0.0 1.7655691964285712e-05 1.8 1.7665736607142857e-05 1.8 1.766629464285714e-05 0.0
+ 1.767299107142857e-05 0.0 1.7673549107142854e-05 1.8 1.7683035714285712e-05 1.8 1.768359375e-05 0.0 1.769140625e-05 0.0
+ 1.7691964285714284e-05 1.8 1.7700892857142855e-05 1.8 1.770145089285714e-05 0.0 1.7709263392857142e-05 0.0
+ 1.7709821428571426e-05 1.8 1.771875e-05 1.8 1.7719308035714284e-05 0.0 1.7727120535714285e-05 0.0 1.772767857142857e-05
+ 1.8 1.7736607142857143e-05 1.8 1.7737165178571426e-05 0.0 1.7744977678571427e-05 0.0
+ 1.7745535714285714e-05 1.8 1.7754464285714285e-05 1.8 1.7755022321428572e-05 0.0 1.776283482142857e-05 0.0
+ 1.7763392857142856e-05 1.8 1.7772321428571427e-05 1.8 1.7772879464285714e-05 0.0 1.7780691964285712e-05 0.0 1.778125e-05
+ 1.8 1.779017857142857e-05 1.8 1.7790736607142856e-05 0.0 1.7798549107142857e-05 0.0
+ 1.779910714285714e-05 1.8 1.7808035714285712e-05 1.8 1.780859375e-05 0.0 1.781640625e-05 0.0 1.7816964285714283e-05 1.8
+ 1.7825892857142854e-05 1.8 1.782645089285714e-05 0.0 1.7834263392857142e-05 0.0 1.783482142857143e-05 1.8 1.784375e-05 1.8
+ 1.7844308035714283e-05 0.0 1.7852120535714284e-05 0.0 1.785267857142857e-05 1.8 1.7861607142857142e-05 1.8
+ 1.7862165178571426e-05 0.0 1.7869977678571427e-05 0.0 1.7870535714285714e-05 1.8 1.7879464285714285e-05 1.8
+ 1.788002232142857e-05 0.0 1.788783482142857e-05 0.0 1.7888392857142856e-05 1.8 1.7897321428571427e-05 1.8
+ 1.7897879464285714e-05 0.0 1.790569196428571e-05 0.0 1.7906249999999998e-05 1.8 1.791517857142857e-05 1.8
+ 1.7915736607142856e-05 0.0 1.7923549107142857e-05 0.0 1.792410714285714e-05 1.8 1.793303571428571e-05 1.8 1.793359375e-05
+ 0.0 1.794140625e-05 0.0 1.7941964285714283e-05 1.8 1.7950892857142857e-05 1.8 1.795145089285714e-05 0.0
+ 1.7959263392857142e-05 0.0 1.795982142857143e-05 1.8 1.796875e-05 1.8 1.7969308035714283e-05 0.0 1.7977120535714284e-05
+ 0.0 1.797767857142857e-05 1.8 1.7986607142857142e-05 1.8 1.798716517857143e-05 0.0
+ 1.7994977678571426e-05 0.0 1.7995535714285713e-05 1.8 1.8003906249999998e-05 1.8 1.8004464285714284e-05 0.0
+ 1.8013392857142856e-05 0.0 1.8013950892857142e-05 1.8 1.802176339285714e-05 1.8 1.8022321428571427e-05 0.0
+ 1.8031249999999998e-05 0.0 1.8031808035714285e-05 1.8 1.8039620535714286e-05 1.8 1.804017857142857e-05 0.0
+ 1.804910714285714e-05 0.0 1.8049665178571427e-05 1.8 1.8057477678571428e-05 1.8 1.805803571428571e-05 0.0
+ 1.8066964285714286e-05 0.0 1.806752232142857e-05 1.8 1.807533482142857e-05 1.8 1.8075892857142857e-05 0.0
+ 1.8084821428571428e-05 0.0 1.808537946428571e-05 1.8 1.8093191964285713e-05 1.8 1.809375e-05 0.0 1.810267857142857e-05 0.0
+ 1.8103236607142857e-05 1.8 1.8111049107142855e-05 1.8 1.811160714285714e-05 0.0 1.8120535714285713e-05 0.0 1.812109375e-05
+ 1.8 1.8128906249999997e-05 1.8 1.8129464285714284e-05 0.0 1.8138392857142855e-05 0.0
+ 1.8138950892857142e-05 1.8 1.8146763392857143e-05 1.8 1.8147321428571426e-05 0.0 1.8156249999999997e-05 0.0
+ 1.8156808035714284e-05 1.8 1.8164620535714285e-05 1.8 1.816517857142857e-05 0.0 1.8174107142857143e-05 0.0
+ 1.8174665178571427e-05 1.8 1.8182477678571428e-05 1.8 1.8183035714285714e-05 0.0 1.8191964285714286e-05 0.0
+ 1.819252232142857e-05 1.8 1.820033482142857e-05 1.8 1.8200892857142857e-05 0.0 1.8209821428571428e-05 0.0
+ 1.8210379464285715e-05 1.8 1.8218191964285712e-05 1.8 1.821875e-05 0.0 1.822767857142857e-05 0.0 1.8228236607142857e-05
+ 1.8 1.8236049107142855e-05 1.8 1.823660714285714e-05 0.0 1.8245535714285712e-05 0.0 1.824609375e-05 1.8
+ 1.825390625e-05 1.8 1.8254464285714284e-05 0.0 1.8263392857142855e-05 0.0 1.826395089285714e-05 1.8
+ 1.8271763392857143e-05 1.8 1.8272321428571426e-05 0.0 1.8281249999999997e-05 0.0 1.8281808035714284e-05 1.8
+ 1.8289620535714285e-05 1.8 1.829017857142857e-05 0.0 1.8299107142857143e-05 0.0 1.8299665178571426e-05 1.8
+ 1.8307477678571427e-05 1.8 1.8308035714285714e-05 0.0 1.8316964285714285e-05 0.0 1.831752232142857e-05 1.8
+ 1.8324776785714283e-05 1.8 1.832533482142857e-05 0.0 1.8335379464285714e-05 0.0 1.8335937499999998e-05 1.8
+ 1.834263392857143e-05 1.8 1.8343191964285712e-05 0.0 1.8353236607142857e-05 0.0 1.835379464285714e-05 1.8
+ 1.836049107142857e-05 1.8 1.8361049107142854e-05 0.0 1.837109375e-05 0.0 1.8371651785714286e-05 1.8
+ 1.8378348214285713e-05 1.8 1.837890625e-05 0.0 1.838895089285714e-05 0.0 1.8389508928571428e-05 1.8 1.8396205357142855e-05
+ 1.8 1.8396763392857142e-05 0.0 1.8406808035714284e-05 0.0 1.840736607142857e-05 1.8
+ 1.8414062499999998e-05 1.8 1.8414620535714285e-05 0.0 1.8424665178571426e-05 0.0 1.8425223214285713e-05 1.8
+ 1.843191964285714e-05 1.8 1.8432477678571427e-05 0.0 1.844252232142857e-05 0.0 1.8443080357142855e-05 1.8
+ 1.8449776785714286e-05 1.8 1.845033482142857e-05 0.0 1.8460379464285714e-05 0.0 1.8460937499999997e-05 1.8
+ 1.8467633928571428e-05 1.8 1.846819196428571e-05 0.0 1.8478236607142856e-05 0.0 1.8478794642857143e-05 1.8
+ 1.848549107142857e-05 1.8 1.8486049107142857e-05 0.0 1.849609375e-05 0.0 1.8496651785714285e-05 1.8
+ 1.8503348214285713e-05 1.8 1.850390625e-05 0.0 1.851395089285714e-05 0.0 1.8514508928571428e-05 1.8 1.8521205357142855e-05
+ 1.8 1.8521763392857142e-05 0.0 1.8531808035714283e-05 0.0 1.853236607142857e-05 1.8
+ 1.8539062499999997e-05 1.8 1.8539620535714284e-05 0.0 1.854966517857143e-05 0.0 1.8550223214285712e-05 1.8
+ 1.8556919642857143e-05 1.8 1.8557477678571427e-05 0.0 1.856752232142857e-05 0.0 1.8568080357142855e-05 1.8
+ 1.8574776785714285e-05 1.8 1.857533482142857e-05 0.0 1.8585379464285714e-05 0.0 1.85859375e-05 1.8 1.8592633928571428e-05
+ 1.8 1.8593191964285715e-05 0.0 1.8603236607142856e-05 0.0 1.8603794642857143e-05 1.8
+ 1.861049107142857e-05 1.8 1.8611049107142857e-05 0.0 1.8621093749999998e-05 0.0 1.8621651785714285e-05 1.8
+ 1.8628348214285712e-05 1.8 1.862890625e-05 0.0 1.863895089285714e-05 0.0 1.8639508928571427e-05 1.8 1.8646205357142855e-05
+ 1.8 1.864676339285714e-05 0.0 1.8656808035714283e-05 0.0 1.865736607142857e-05 1.8
+ 1.8664062499999997e-05 1.8 1.8664620535714284e-05 0.0 1.8675223214285712e-05 0.0 1.867578125e-05 1.8
+ 1.8681361607142856e-05 1.8 1.8681919642857143e-05 0.0 1.8693080357142854e-05 0.0 1.869363839285714e-05 1.8 1.869921875e-05
+ 1.8 1.8699776785714285e-05 0.0 1.87109375e-05 0.0 1.8711495535714283e-05 1.8 1.871707589285714e-05 1.8
+ 1.8717633928571427e-05 0.0 1.8728794642857142e-05 0.0 1.8729352678571426e-05 1.8 1.8734933035714283e-05 1.8
+ 1.873549107142857e-05 0.0 1.8746651785714285e-05 0.0 1.874720982142857e-05 1.8 1.875279017857143e-05 1.8
+ 1.8753348214285712e-05 0.0 1.8764508928571427e-05 0.0 1.8765066964285714e-05 1.8 1.877064732142857e-05 1.8
+ 1.8771205357142854e-05 0.0 1.878236607142857e-05 0.0 1.8782924107142856e-05 1.8 1.8788504464285713e-05 1.8 1.87890625e-05
+ 0.0 1.880022321428571e-05 0.0 1.880078125e-05 1.8 1.8806361607142856e-05 1.8 1.8806919642857142e-05 0.0
+ 1.8818080357142857e-05 0.0 1.881863839285714e-05 1.8 1.8824218749999998e-05 1.8 1.8824776785714285e-05 0.0 1.88359375e-05
+ 0.0 1.8836495535714283e-05 1.8 1.884207589285714e-05 1.8 1.8842633928571427e-05 0.0
+ 1.8853794642857142e-05 0.0 1.885435267857143e-05 1.8 1.8859933035714283e-05 1.8 1.886049107142857e-05 0.0
+ 1.8871651785714284e-05 0.0 1.887220982142857e-05 1.8 1.887779017857143e-05 1.8 1.8878348214285712e-05 0.0
+ 1.8889508928571427e-05 0.0 1.8890066964285713e-05 1.8 1.889564732142857e-05 1.8 1.8896205357142857e-05 0.0
+ 1.890736607142857e-05 0.0 1.8907924107142856e-05 1.8 1.8913504464285713e-05 1.8 1.89140625e-05 0.0 1.8925223214285715e-05
+ 0.0 1.8925781249999998e-05 1.8 1.8931361607142855e-05 1.8 1.8931919642857142e-05 0.0
+ 1.8943080357142857e-05 0.0 1.894363839285714e-05 1.8 1.8949218749999998e-05 1.8 1.8949776785714284e-05 0.0 1.89609375e-05
+ 0.0 1.8961495535714286e-05 1.8 1.896707589285714e-05 1.8 1.8967633928571427e-05 0.0
+ 1.897879464285714e-05 0.0 1.897935267857143e-05 1.8 1.8984933035714286e-05 1.8 1.898549107142857e-05 0.0
+ 1.8996651785714284e-05 0.0 1.899720982142857e-05 1.8 1.9002790178571428e-05 1.8 1.900334821428571e-05 0.0
+ 1.9014508928571426e-05 0.0 1.9015066964285713e-05 1.8 1.902064732142857e-05 1.8 1.9021205357142857e-05 0.0
+ 1.903236607142857e-05 0.0 1.9032924107142855e-05 1.8 1.9038504464285713e-05 1.8 1.90390625e-05 0.0 1.9050223214285714e-05
+ 0.0 1.9050781249999998e-05 1.8 1.9056361607142855e-05 1.8 1.9056919642857142e-05 0.0
+ 1.9068080357142857e-05 0.0 1.906863839285714e-05 1.8 1.9074218749999997e-05 1.8 1.9074776785714284e-05 0.0
+ 1.9086495535714286e-05 0.0 1.908705357142857e-05 1.8 1.9091517857142856e-05 1.8 1.9092075892857143e-05 0.0
+ 1.9104352678571428e-05 0.0 1.910491071428571e-05 1.8 1.9109375e-05 1.8 1.9109933035714285e-05 0.0 1.912220982142857e-05
+ 0.0 1.9122767857142857e-05 1.8 1.912723214285714e-05 1.8 1.9127790178571428e-05 0.0
+ 1.9140066964285713e-05 0.0 1.9140625e-05 1.8 1.9145089285714283e-05 1.8 1.914564732142857e-05 0.0 1.9157924107142855e-05
+ 0.0 1.9158482142857142e-05 1.8 1.9162946428571426e-05 1.8 1.9163504464285712e-05 0.0
+ 1.9175781249999997e-05 0.0 1.9176339285714284e-05 1.8 1.918080357142857e-05 1.8 1.9181361607142855e-05 0.0
+ 1.9193638392857143e-05 0.0 1.9194196428571426e-05 1.8 1.9198660714285714e-05 1.8 1.9199218749999997e-05 0.0
+ 1.9211495535714285e-05 0.0 1.921205357142857e-05 1.8 1.9216517857142856e-05 1.8 1.9217075892857143e-05 0.0
+ 1.9229352678571428e-05 0.0 1.9229910714285714e-05 1.8 1.9234374999999998e-05 1.8 1.9234933035714285e-05 0.0
+ 1.924720982142857e-05 0.0 1.9247767857142857e-05 1.8 1.925223214285714e-05 1.8 1.9252790178571427e-05 0.0
+ 1.9265066964285712e-05 0.0 1.9265625e-05 1.8 1.9270089285714283e-05 1.8 1.927064732142857e-05 0.0 1.9282924107142855e-05
+ 0.0 1.928348214285714e-05 1.8 1.928794642857143e-05 1.8 1.9288504464285712e-05 0.0
+ 1.9300781249999997e-05 0.0 1.9301339285714284e-05 1.8 1.930580357142857e-05 1.8 1.9306361607142854e-05 0.0
+ 1.9318638392857143e-05 0.0 1.9319196428571426e-05 1.8 1.9323660714285713e-05 1.8 1.932421875e-05 0.0
+ 1.9336495535714285e-05 0.0 1.9337053571428572e-05 1.8 1.9341517857142856e-05 1.8 1.9342075892857142e-05 0.0
+ 1.9354352678571427e-05 0.0 1.9354910714285714e-05 1.8 1.9359374999999998e-05 1.8 1.9359933035714285e-05 0.0
+ 1.937220982142857e-05 0.0 1.9372767857142856e-05 1.8 1.937723214285714e-05 1.8 1.9377790178571427e-05 0.0
+ 1.9390066964285712e-05 0.0 1.9390625e-05 1.8 1.9395089285714286e-05 1.8 1.939564732142857e-05 0.0 1.9407924107142854e-05
+ 0.0 1.940848214285714e-05 1.8 1.9412946428571428e-05 1.8 1.941350446428571e-05 0.0 1.942578125e-05 0.0
+ 1.9426339285714283e-05 1.8 1.943080357142857e-05 1.8 1.9431361607142857e-05 0.0 1.9443638392857142e-05 0.0
+ 1.9444196428571426e-05 1.8 1.9448660714285713e-05 1.8 1.944921875e-05 0.0 1.9461495535714285e-05 0.0 1.946205357142857e-05
+ 1.8 1.9466517857142855e-05 1.8 1.9467075892857142e-05 0.0 1.9479352678571427e-05 0.0
+ 1.9479910714285714e-05 1.8 1.9484374999999998e-05 1.8 1.9484933035714284e-05 0.0 1.949720982142857e-05 0.0
+ 1.9497767857142856e-05 1.8 1.950223214285714e-05 1.8 1.9502790178571427e-05 0.0 1.951506696428571e-05 0.0 1.9515625e-05
+ 1.8 1.9520089285714286e-05 1.8 1.952064732142857e-05 0.0 1.9532924107142857e-05 0.0
+ 1.953348214285714e-05 1.8 1.9537946428571428e-05 1.8 1.953850446428571e-05 0.0 1.955078125e-05 0.0 1.9551339285714283e-05
+ 1.8 1.955580357142857e-05 1.8 1.9556361607142857e-05 0.0 1.9568638392857142e-05 0.0
+ 1.956919642857143e-05 1.8 1.9573660714285713e-05 1.8 1.957421875e-05 0.0 1.9586495535714284e-05 0.0 1.958705357142857e-05
+ 1.8 1.9591517857142855e-05 1.8 1.959207589285714e-05 0.0 1.9604352678571427e-05 0.0
+ 1.9604910714285713e-05 1.8 1.9609374999999997e-05 1.8 1.9609933035714284e-05 0.0 1.962220982142857e-05 0.0
+ 1.9622767857142856e-05 1.8 1.9627232142857143e-05 1.8 1.9627790178571426e-05 0.0 1.964006696428571e-05 0.0
+ 1.9640624999999998e-05 1.8 1.9645089285714285e-05 1.8 1.964564732142857e-05 0.0 1.9657924107142857e-05 0.0
+ 1.965848214285714e-05 1.8 1.9662946428571428e-05 1.8 1.9663504464285714e-05 0.0 1.967578125e-05 0.0
+ 1.9676339285714283e-05 1.8 1.968080357142857e-05 1.8 1.9681361607142857e-05 0.0 1.969363839285714e-05 0.0
+ 1.969419642857143e-05 1.8 1.9698660714285712e-05 1.8 1.969921875e-05 0.0 1.9711495535714284e-05 0.0 1.971205357142857e-05
+ 1.8 1.9716517857142855e-05 1.8 1.971707589285714e-05 0.0 1.9729352678571426e-05 0.0
+ 1.9729910714285713e-05 1.8 1.9734375e-05 1.8 1.9734933035714284e-05 0.0 1.974720982142857e-05 0.0 1.9747767857142855e-05
+ 1.8 1.9752232142857143e-05 1.8 1.9752790178571426e-05 0.0 1.9765066964285714e-05 0.0
+ 1.9765624999999998e-05 1.8 1.9770089285714285e-05 1.8 1.977064732142857e-05 0.0 1.9782924107142857e-05 0.0
+ 1.978348214285714e-05 1.8 1.9787946428571427e-05 1.8 1.9788504464285714e-05 0.0 1.980078125e-05 0.0
+ 1.9801339285714286e-05 1.8 1.980580357142857e-05 1.8 1.9806361607142856e-05 0.0 1.981863839285714e-05 0.0
+ 1.9819196428571428e-05 1.8 1.9823660714285712e-05 1.8 1.982421875e-05 0.0 1.9836495535714284e-05 0.0 1.983705357142857e-05
+ 1.8 1.9841517857142854e-05 1.8 1.984207589285714e-05 0.0 1.9854352678571426e-05 0.0
+ 1.9854910714285713e-05 1.8 1.9859375e-05 1.8 1.9859933035714283e-05 0.0 1.987220982142857e-05 0.0 1.9872767857142855e-05
+ 1.8 1.9877232142857142e-05 1.8 1.9877790178571426e-05 0.0 1.9890066964285714e-05 0.0
+ 1.9890624999999997e-05 1.8 1.9895089285714285e-05 1.8 1.989564732142857e-05 0.0 1.9907924107142856e-05 0.0
+ 1.9908482142857143e-05 1.8 1.9912946428571427e-05 1.8 1.9913504464285714e-05 0.0 1.992578125e-05 0.0
+ 1.9926339285714285e-05 1.8 1.993080357142857e-05 1.8 1.9931361607142856e-05 0.0 1.994363839285714e-05 0.0
+ 1.9944196428571428e-05 1.8 1.994866071428571e-05 1.8 1.9949218749999998e-05 0.0 1.9961495535714283e-05 0.0
+ 1.996205357142857e-05 1.8 1.9966517857142857e-05 1.8 1.996707589285714e-05 0.0 1.9979352678571426e-05 0.0
+ 1.9979910714285712e-05 1.8 1.9984375e-05 1.8 1.9984933035714283e-05 0.0 1.999720982142857e-05 0.0 1.9997767857142855e-05
+ 1.8 2.0002232142857142e-05 1.8 2.000279017857143e-05 0.0 2.0015066964285714e-05 0.0
+ 2.0015624999999997e-05 1.8 2.0020089285714284e-05 1.8 2.002064732142857e-05 0.0 2.0032924107142856e-05 0.0
+ 2.0033482142857143e-05 1.8 2.0037946428571427e-05 1.8 2.0038504464285713e-05 0.0 2.0050781249999998e-05 0.0
+ 2.0051339285714285e-05 1.8 2.005580357142857e-05 1.8 2.0056361607142856e-05 0.0 2.006863839285714e-05 0.0
+ 2.0069196428571427e-05 1.8 2.007366071428571e-05 1.8 2.0074218749999998e-05 0.0 2.0086495535714283e-05 0.0
+ 2.008705357142857e-05 1.8 2.0091517857142857e-05 1.8 2.009207589285714e-05 0.0 2.010435267857143e-05 0.0
+ 2.0104910714285712e-05 1.8 2.0109375e-05 1.8 2.0109933035714283e-05 0.0 2.012220982142857e-05 0.0 2.0122767857142854e-05
+ 1.8 2.012723214285714e-05 1.8 2.0127790178571428e-05 0.0 2.0140066964285713e-05 0.0 2.0140625e-05 1.8
+ 2.0145089285714284e-05 1.8 2.014564732142857e-05 0.0 2.0157924107142856e-05 0.0 2.0158482142857142e-05 1.8
+ 2.0162946428571426e-05 1.8 2.0163504464285713e-05 0.0 2.0175781249999998e-05 0.0 2.0176339285714285e-05 1.8
+ 2.018080357142857e-05 1.8 2.0181361607142855e-05 0.0 2.019363839285714e-05 0.0 2.0194196428571427e-05 1.8
+ 2.0198660714285714e-05 1.8 2.0199218749999998e-05 0.0 2.0211495535714286e-05 0.0 2.021205357142857e-05 1.8
+ 2.0216517857142857e-05 1.8 2.021707589285714e-05 0.0 2.0229352678571428e-05 0.0 2.022991071428571e-05 1.8 2.0234375e-05
+ 1.8 2.0234933035714286e-05 0.0 2.024720982142857e-05 0.0 2.0247767857142857e-05 1.8
+ 2.025223214285714e-05 1.8 2.0252790178571428e-05 0.0 2.0265066964285713e-05 0.0 2.0265625e-05 1.8 2.0270089285714284e-05
+ 1.8 2.027064732142857e-05 0.0 2.0282924107142855e-05 0.0 2.0283482142857142e-05 1.8
+ 2.0287946428571426e-05 1.8 2.0288504464285713e-05 0.0 2.0300781249999998e-05 0.0 2.0301339285714284e-05 1.8
+ 2.030580357142857e-05 1.8 2.0306361607142855e-05 0.0 2.031863839285714e-05 0.0 2.0319196428571427e-05 1.8
+ 2.0323660714285714e-05 1.8 2.0324218749999997e-05 0.0 2.0336495535714286e-05 0.0 2.033705357142857e-05 1.8
+ 2.0341517857142856e-05 1.8 2.0342075892857143e-05 0.0 2.0354352678571428e-05 0.0 2.035491071428571e-05 1.8 2.0359375e-05
+ 1.8 2.0359933035714285e-05 0.0 2.037220982142857e-05 0.0 2.0372767857142857e-05 1.8
+ 2.037723214285714e-05 1.8 2.0377790178571428e-05 0.0 2.0390066964285713e-05 0.0 2.0390625e-05 1.8 2.0395089285714283e-05
+ 1.8 2.039564732142857e-05 0.0 2.0407924107142855e-05 0.0 2.040848214285714e-05 1.8
+ 2.0412946428571425e-05 1.8 2.0413504464285712e-05 0.0 2.0425781249999997e-05 0.0 2.0426339285714284e-05 1.8
+ 2.043080357142857e-05 1.8 2.0431361607142855e-05 0.0 2.0443638392857143e-05 0.0 2.0444196428571426e-05 1.8
+ 2.0448660714285714e-05 1.8 2.0449218749999997e-05 0.0 2.0461495535714285e-05 0.0 2.046205357142857e-05 1.8
+ 2.0466517857142856e-05 1.8 2.0467075892857143e-05 0.0 2.0479352678571428e-05 0.0 2.0479910714285714e-05 1.8
+ 2.0484374999999998e-05 1.8 2.0484933035714285e-05 0.0 2.049720982142857e-05 0.0 2.0497767857142857e-05 1.8
+ 2.050223214285714e-05 1.8 2.0502790178571427e-05 0.0 2.0515066964285712e-05 0.0 2.0515625e-05 1.8 2.0520089285714283e-05
+ 1.8 2.052064732142857e-05 0.0 2.0532924107142854e-05 0.0 2.053348214285714e-05 1.8
+ 2.053794642857143e-05 1.8 2.0538504464285712e-05 0.0 2.055078125e-05 0.0 2.0551339285714284e-05 1.8 2.055580357142857e-05
+ 1.8 2.0556361607142854e-05 0.0 2.0568638392857143e-05 0.0 2.0569196428571426e-05 1.8
+ 2.0573660714285713e-05 1.8 2.057421875e-05 0.0 2.0586495535714285e-05 0.0 2.058705357142857e-05 1.8 2.0591517857142855e-05
+ 1.8 2.0592075892857142e-05 0.0 2.0604352678571427e-05 0.0 2.0604910714285714e-05 1.8
+ 2.0609374999999998e-05 1.8 2.0609933035714285e-05 0.0 2.062220982142857e-05 0.0 2.0622767857142856e-05 1.8
+ 2.062723214285714e-05 1.8 2.0627790178571427e-05 0.0 2.0640066964285712e-05 0.0 2.0640625e-05 1.8 2.0645089285714286e-05
+ 1.8 2.064564732142857e-05 0.0 2.0657924107142854e-05 0.0 2.065848214285714e-05 1.8
+ 2.0662946428571428e-05 1.8 2.066350446428571e-05 0.0 2.067578125e-05 0.0 2.0676339285714283e-05 1.8 2.068080357142857e-05
+ 1.8 2.0681361607142857e-05 0.0 2.0693638392857142e-05 0.0 2.0694196428571426e-05 1.8
+ 2.0698660714285713e-05 1.8 2.069921875e-05 0.0 2.0711495535714284e-05 0.0 2.071205357142857e-05 1.8 2.0716517857142855e-05
+ 1.8 2.0717075892857142e-05 0.0 2.0729352678571427e-05 0.0 2.0729910714285714e-05 1.8
+ 2.0734374999999997e-05 1.8 2.0734933035714284e-05 0.0 2.074720982142857e-05 0.0 2.0747767857142856e-05 1.8
+ 2.075223214285714e-05 1.8 2.0752790178571427e-05 0.0 2.076506696428571e-05 0.0 2.0765624999999998e-05 1.8
+ 2.0770089285714285e-05 1.8 2.077064732142857e-05 0.0 2.0782924107142857e-05 0.0 2.078348214285714e-05 1.8
+ 2.0787946428571428e-05 1.8 2.078850446428571e-05 0.0 2.080078125e-05 0.0 2.0801339285714283e-05 1.8 2.080580357142857e-05
+ 1.8 2.0806361607142857e-05 0.0 2.0818638392857142e-05 0.0 2.081919642857143e-05 1.8
+ 2.0823660714285712e-05 1.8 2.082421875e-05 0.0 2.0836495535714284e-05 0.0 2.083705357142857e-05 1.8 2.0841517857142855e-05
+ 1.8 2.084207589285714e-05 0.0 2.0854352678571426e-05 0.0 2.0854910714285713e-05 1.8
+ 2.0859374999999997e-05 1.8 2.0859933035714284e-05 0.0 2.087220982142857e-05 0.0 2.0872767857142856e-05 1.8
+ 2.0877232142857143e-05 1.8 2.0877790178571426e-05 0.0 2.089006696428571e-05 0.0 2.0890624999999998e-05 1.8
+ 2.0895089285714285e-05 1.8 2.089564732142857e-05 0.0 2.0907924107142857e-05 0.0 2.090848214285714e-05 1.8
+ 2.0912946428571427e-05 1.8 2.0913504464285714e-05 0.0 2.0925223214285712e-05 0.0 2.092578125e-05 1.8
+ 2.0931361607142857e-05 1.8 2.093191964285714e-05 0.0 2.0943080357142855e-05 0.0 2.094363839285714e-05 1.8 2.094921875e-05
+ 1.8 2.0949776785714286e-05 0.0 2.0960937499999997e-05 0.0 2.0961495535714284e-05 1.8
+ 2.096707589285714e-05 1.8 2.0967633928571428e-05 0.0 2.0978794642857143e-05 0.0 2.0979352678571426e-05 1.8
+ 2.0984933035714284e-05 1.8 2.098549107142857e-05 0.0 2.0996651785714285e-05 0.0 2.099720982142857e-05 1.8
+ 2.1002790178571426e-05 1.8 2.1003348214285713e-05 0.0 2.1014508928571427e-05 0.0 2.1015066964285714e-05 1.8
+ 2.102064732142857e-05 1.8 2.1021205357142855e-05 0.0 2.103236607142857e-05 0.0 2.1032924107142856e-05 1.8
+ 2.1038504464285714e-05 1.8 2.1039062499999997e-05 0.0 2.1050223214285712e-05 0.0 2.105078125e-05 1.8
+ 2.1056361607142856e-05 1.8 2.1056919642857143e-05 0.0 2.1068080357142854e-05 0.0 2.106863839285714e-05 1.8 2.107421875e-05
+ 1.8 2.1074776785714285e-05 0.0 2.10859375e-05 0.0 2.1086495535714283e-05 1.8 2.109207589285714e-05 1.8
+ 2.1092633928571428e-05 0.0 2.1103794642857142e-05 0.0 2.1104352678571426e-05 1.8 2.1109933035714283e-05 1.8
+ 2.111049107142857e-05 0.0 2.1121651785714285e-05 0.0 2.112220982142857e-05 1.8 2.1127790178571425e-05 1.8
+ 2.1128348214285712e-05 0.0 2.1139508928571427e-05 0.0 2.1140066964285714e-05 1.8 2.114564732142857e-05 1.8
+ 2.1146205357142855e-05 0.0 2.115736607142857e-05 0.0 2.1157924107142856e-05 1.8 2.1163504464285714e-05 1.8
+ 2.1164062499999997e-05 0.0 2.1175223214285712e-05 0.0 2.117578125e-05 1.8 2.1181361607142856e-05 1.8
+ 2.1181919642857143e-05 0.0 2.1193080357142854e-05 0.0 2.119363839285714e-05 1.8 2.1199218749999998e-05 1.8
+ 2.1199776785714285e-05 0.0 2.12109375e-05 0.0 2.1211495535714283e-05 1.8 2.121707589285714e-05 1.8 2.1217633928571427e-05
+ 0.0 2.1228794642857142e-05 0.0 2.1229352678571425e-05 1.8 2.1234933035714283e-05 1.8
+ 2.123549107142857e-05 0.0 2.1246651785714284e-05 0.0 2.124720982142857e-05 1.8 2.125279017857143e-05 1.8
+ 2.1253348214285712e-05 0.0 2.1264508928571427e-05 0.0 2.1265066964285713e-05 1.8 2.127064732142857e-05 1.8
+ 2.1271205357142854e-05 0.0 2.128236607142857e-05 0.0 2.1282924107142856e-05 1.8 2.1288504464285713e-05 1.8 2.12890625e-05
+ 0.0 2.130022321428571e-05 0.0 2.1300781249999998e-05 1.8 2.1306361607142856e-05 1.8
+ 2.1306919642857142e-05 0.0 2.1318080357142857e-05 0.0 2.131863839285714e-05 1.8 2.1324218749999998e-05 1.8
+ 2.1324776785714285e-05 0.0 2.1335379464285713e-05 0.0 2.13359375e-05 1.8 2.1342633928571427e-05 1.8 2.1343191964285714e-05
+ 0.0 2.1353236607142855e-05 0.0 2.1353794642857142e-05 1.8 2.136049107142857e-05 1.8
+ 2.1361049107142856e-05 0.0 2.1371093749999997e-05 0.0 2.1371651785714284e-05 1.8 2.137834821428571e-05 1.8 2.137890625e-05
+ 0.0 2.1388950892857143e-05 0.0 2.1389508928571426e-05 1.8 2.1396205357142857e-05 1.8
+ 2.139676339285714e-05 0.0 2.1406808035714285e-05 0.0 2.140736607142857e-05 1.8 2.14140625e-05 1.8 2.1414620535714283e-05
+ 0.0 2.1424665178571428e-05 0.0 2.1425223214285714e-05 1.8 2.1431919642857142e-05 1.8
+ 2.143247767857143e-05 0.0 2.144252232142857e-05 0.0 2.1443080357142857e-05 1.8 2.1449776785714284e-05 1.8
+ 2.145033482142857e-05 0.0 2.1460379464285712e-05 0.0 2.14609375e-05 1.8 2.1467633928571427e-05 1.8 2.1468191964285713e-05
+ 0.0 2.1478236607142855e-05 0.0 2.147879464285714e-05 1.8 2.148549107142857e-05 1.8
+ 2.1486049107142856e-05 0.0 2.1496093749999997e-05 0.0 2.1496651785714284e-05 1.8 2.150334821428571e-05 1.8
+ 2.1503906249999998e-05 0.0 2.1513950892857143e-05 0.0 2.1514508928571426e-05 1.8 2.1521205357142857e-05 1.8
+ 2.152176339285714e-05 0.0 2.1531808035714285e-05 0.0 2.153236607142857e-05 1.8 2.15390625e-05 1.8 2.1539620535714283e-05
+ 0.0 2.1549665178571427e-05 0.0 2.1550223214285714e-05 1.8 2.155691964285714e-05 1.8
+ 2.155747767857143e-05 0.0 2.156752232142857e-05 0.0 2.1568080357142856e-05 1.8 2.1574776785714284e-05 1.8
+ 2.157533482142857e-05 0.0 2.1585379464285712e-05 0.0 2.15859375e-05 1.8 2.1592633928571426e-05 1.8 2.1593191964285713e-05
+ 0.0 2.1603236607142854e-05 0.0 2.160379464285714e-05 1.8 2.161049107142857e-05 1.8
+ 2.1611049107142855e-05 0.0 2.162109375e-05 0.0 2.1621651785714283e-05 1.8 2.1628348214285714e-05 1.8
+ 2.1628906249999998e-05 0.0 2.1638950892857142e-05 0.0 2.1639508928571426e-05 1.8 2.1646205357142857e-05 1.8
+ 2.164676339285714e-05 0.0 2.1656808035714285e-05 0.0 2.165736607142857e-05 1.8 2.16640625e-05 1.8 2.1664620535714286e-05
+ 0.0 2.1674665178571427e-05 0.0 2.1675223214285714e-05 1.8 2.1682477678571428e-05 1.8
+ 2.168303571428571e-05 0.0 2.1691964285714282e-05 0.0 2.169252232142857e-05 1.8 2.170033482142857e-05 1.8
+ 2.1700892857142857e-05 0.0 2.1709821428571428e-05 0.0 2.171037946428571e-05 1.8 2.1718191964285713e-05 1.8 2.171875e-05
+ 0.0 2.172767857142857e-05 0.0 2.1728236607142854e-05 1.8 2.1736049107142855e-05 1.8
+ 2.173660714285714e-05 0.0 2.1745535714285713e-05 0.0 2.174609375e-05 1.8 2.1753906249999997e-05 1.8
+ 2.1754464285714284e-05 0.0 2.1763392857142855e-05 0.0 2.1763950892857142e-05 1.8 2.1771763392857143e-05 1.8
+ 2.1772321428571426e-05 0.0 2.1781249999999997e-05 0.0 2.1781808035714284e-05 1.8 2.1789620535714285e-05 1.8
+ 2.179017857142857e-05 0.0 2.179910714285714e-05 0.0 2.1799665178571427e-05 1.8 2.1807477678571428e-05 1.8
+ 2.1808035714285714e-05 0.0 2.1816964285714286e-05 0.0 2.181752232142857e-05 1.8 2.182533482142857e-05 1.8
+ 2.1825892857142857e-05 0.0 2.1834821428571428e-05 0.0 2.183537946428571e-05 1.8 2.1843191964285712e-05 1.8 2.184375e-05
+ 0.0 2.185267857142857e-05 0.0 2.1853236607142857e-05 1.8 2.1861049107142855e-05 1.8
+ 2.186160714285714e-05 0.0 2.1870535714285713e-05 0.0 2.187109375e-05 1.8 2.1878906249999997e-05 1.8
+ 2.1879464285714284e-05 0.0 2.1888392857142855e-05 0.0 2.188895089285714e-05 1.8 2.1896763392857143e-05 1.8
+ 2.1897321428571426e-05 0.0 2.1906249999999997e-05 0.0 2.1906808035714284e-05 1.8 2.1914620535714285e-05 1.8
+ 2.191517857142857e-05 0.0 2.1924107142857143e-05 0.0 2.1924665178571426e-05 1.8 2.1932477678571427e-05 1.8
+ 2.1933035714285714e-05 0.0 2.1941964285714285e-05 0.0 2.194252232142857e-05 1.8 2.195033482142857e-05 1.8
+ 2.1950892857142856e-05 0.0 2.1959821428571428e-05 0.0 2.1960379464285714e-05 1.8 2.1968191964285712e-05 1.8 2.196875e-05
+ 0.0 2.197767857142857e-05 0.0 2.1978236607142857e-05 1.8 2.1986049107142854e-05 1.8
+ 2.198660714285714e-05 0.0 2.1995535714285712e-05 0.0 2.199609375e-05 1.8 2.2004464285714283e-05 1.8 2.200502232142857e-05
+ 0.0 2.201283482142857e-05 0.0 2.2013392857142854e-05 1.8 2.2022321428571426e-05 1.8
+ 2.2022879464285712e-05 0.0 2.2030691964285713e-05 0.0 2.2031249999999997e-05 1.8 2.204017857142857e-05 1.8
+ 2.2040736607142855e-05 0.0 2.2048549107142856e-05 0.0 2.2049107142857143e-05 1.8 2.2058035714285714e-05 1.8
+ 2.2058593749999997e-05 0.0 2.2066406249999998e-05 0.0 2.2066964285714285e-05 1.8 2.2075892857142856e-05 1.8
+ 2.2076450892857143e-05 0.0 2.208426339285714e-05 0.0 2.2084821428571427e-05 1.8 2.209375e-05 1.8 2.2094308035714285e-05
+ 0.0 2.2102120535714283e-05 0.0 2.210267857142857e-05 1.8 2.211160714285714e-05 1.8
+ 2.2112165178571427e-05 0.0 2.211997767857143e-05 0.0 2.2120535714285712e-05 1.8 2.2129464285714283e-05 1.8
+ 2.213002232142857e-05 0.0 2.213783482142857e-05 0.0 2.2138392857142854e-05 1.8 2.214732142857143e-05 1.8
+ 2.2147879464285712e-05 0.0 2.2155691964285713e-05 0.0 2.215625e-05 1.8 2.216517857142857e-05 1.8 2.2165736607142854e-05
+ 0.0 2.2173549107142855e-05 0.0 2.2174107142857142e-05 1.8 2.2183035714285713e-05 1.8 2.218359375e-05
+ 0.0 2.2191406249999998e-05 0.0 2.2191964285714284e-05 1.8 2.2200892857142856e-05 1.8
+ 2.2201450892857142e-05 0.0 2.220926339285714e-05 0.0 2.2209821428571427e-05 1.8 2.2218749999999998e-05 1.8
+ 2.2219308035714285e-05 0.0 2.2227120535714286e-05 0.0 2.222767857142857e-05 1.8 2.223660714285714e-05 1.8
+ 2.2237165178571427e-05 0.0 2.2244977678571428e-05 0.0 2.224553571428571e-05 1.8 2.2254464285714283e-05 1.8
+ 2.225502232142857e-05 0.0 2.226283482142857e-05 0.0 2.2263392857142857e-05 1.8 2.227232142857143e-05 1.8
+ 2.2272879464285712e-05 0.0 2.2280691964285713e-05 0.0 2.228125e-05 1.8 2.229017857142857e-05 1.8 2.2290736607142854e-05
+ 0.0 2.2298549107142855e-05 0.0 2.2299107142857142e-05 1.8 2.2308035714285713e-05 1.8 2.230859375e-05
+ 0.0 2.2316406249999997e-05 0.0 2.2316964285714284e-05 1.8 2.2326450892857142e-05 1.8
+ 2.2327008928571425e-05 0.0 2.2333705357142856e-05 0.0 2.233426339285714e-05 1.8 2.2344308035714284e-05 1.8
+ 2.234486607142857e-05 0.0 2.23515625e-05 0.0 2.2352120535714285e-05 1.8 2.2362165178571427e-05 1.8 2.2362723214285713e-05
+ 0.0 2.236941964285714e-05 0.0 2.2369977678571428e-05 1.8 2.238002232142857e-05 1.8
+ 2.2380580357142856e-05 0.0 2.2387276785714283e-05 0.0 2.238783482142857e-05 1.8 2.239787946428571e-05 1.8
+ 2.2398437499999998e-05 0.0 2.2405133928571426e-05 0.0 2.2405691964285712e-05 1.8 2.2415736607142857e-05 1.8
+ 2.241629464285714e-05 0.0 2.242299107142857e-05 0.0 2.2423549107142855e-05 1.8 2.243359375e-05 1.8 2.2434151785714283e-05
+ 0.0 2.2440848214285714e-05 0.0 2.2441406249999997e-05 1.8 2.2451450892857142e-05 1.8
+ 2.245200892857143e-05 0.0 2.2458705357142856e-05 0.0 2.2459263392857143e-05 1.8 2.2469308035714284e-05 1.8
+ 2.246986607142857e-05 0.0 2.24765625e-05 0.0 2.2477120535714285e-05 1.8 2.2487165178571426e-05 1.8 2.2487723214285713e-05
+ 0.0 2.249441964285714e-05 0.0 2.2494977678571427e-05 1.8 2.250502232142857e-05 1.8
+ 2.2505580357142855e-05 0.0 2.2512276785714283e-05 0.0 2.251283482142857e-05 1.8 2.252287946428571e-05 1.8
+ 2.2523437499999998e-05 0.0 2.2530133928571425e-05 0.0 2.2530691964285712e-05 1.8 2.2540736607142857e-05 1.8
+ 2.254129464285714e-05 0.0 2.254799107142857e-05 0.0 2.2548549107142854e-05 1.8 2.255859375e-05 1.8 2.2559151785714286e-05
+ 0.0 2.2565848214285713e-05 0.0 2.256640625e-05 1.8 2.257645089285714e-05 1.8 2.2577008928571428e-05 0.0
+ 2.2583705357142856e-05 0.0 2.2584263392857142e-05 1.8 2.2594308035714284e-05 1.8 2.259486607142857e-05 0.0
+ 2.2601562499999998e-05 0.0 2.2602120535714285e-05 1.8 2.2612165178571426e-05 1.8 2.2612723214285713e-05 0.0
+ 2.261941964285714e-05 0.0 2.2619977678571427e-05 1.8 2.263002232142857e-05 1.8 2.2630580357142855e-05 0.0
+ 2.2637276785714283e-05 0.0 2.263783482142857e-05 1.8 2.2647879464285714e-05 1.8 2.2648437499999997e-05 0.0
+ 2.265513392857143e-05 0.0 2.265569196428571e-05 1.8 2.2665736607142856e-05 1.8 2.266629464285714e-05 0.0
+ 2.2672433035714284e-05 0.0 2.267299107142857e-05 1.8 2.2684151785714285e-05 1.8 2.268470982142857e-05 0.0
+ 2.2690290178571426e-05 0.0 2.2690848214285713e-05 1.8 2.2702008928571428e-05 1.8 2.270256696428571e-05 0.0
+ 2.270814732142857e-05 0.0 2.2708705357142855e-05 1.8 2.271986607142857e-05 1.8 2.2720424107142857e-05 0.0
+ 2.2726004464285714e-05 0.0 2.2726562499999998e-05 1.8 2.2737723214285712e-05 1.8 2.273828125e-05 0.0
+ 2.2743861607142857e-05 0.0 2.274441964285714e-05 1.8 2.2755580357142855e-05 1.8 2.275613839285714e-05 0.0 2.276171875e-05
+ 0.0 2.2762276785714286e-05 1.8 2.2773437499999997e-05 1.8 2.2773995535714284e-05 0.0
+ 2.277957589285714e-05 0.0 2.2780133928571428e-05 1.8 2.2791294642857143e-05 1.8 2.2791852678571426e-05 0.0
+ 2.2797433035714284e-05 0.0 2.279799107142857e-05 1.8 2.2809151785714285e-05 1.8 2.280970982142857e-05 0.0
+ 2.2815290178571426e-05 0.0 2.2815848214285713e-05 1.8 2.2827008928571427e-05 1.8 2.2827566964285714e-05 0.0
+ 2.2833147321428568e-05 0.0 2.2833705357142855e-05 1.8 2.284486607142857e-05 1.8 2.2845424107142856e-05 0.0
+ 2.2851004464285714e-05 0.0 2.2851562499999997e-05 1.8 2.2862723214285712e-05 1.8 2.286328125e-05 0.0
+ 2.2868861607142856e-05 0.0 2.286941964285714e-05 1.8 2.2880580357142854e-05 1.8 2.288113839285714e-05 0.0 2.288671875e-05
+ 0.0 2.2887276785714285e-05 1.8 2.2898437499999997e-05 1.8 2.2898995535714283e-05 0.0
+ 2.290457589285714e-05 0.0 2.2905133928571428e-05 1.8 2.2916294642857142e-05 1.8 2.2916852678571426e-05 0.0
+ 2.2922433035714283e-05 0.0 2.292299107142857e-05 1.8 2.2934151785714285e-05 1.8 2.2934709821428568e-05 0.0
+ 2.2940290178571426e-05 0.0 2.2940848214285712e-05 1.8 2.2952008928571427e-05 1.8 2.2952566964285714e-05 0.0
+ 2.295814732142857e-05 0.0 2.2958705357142855e-05 1.8 2.296986607142857e-05 1.8 2.2970424107142856e-05 0.0
+ 2.2976004464285714e-05 0.0 2.2976562499999997e-05 1.8 2.2987723214285712e-05 1.8 2.298828125e-05 0.0
+ 2.2993861607142856e-05 0.0 2.2994419642857143e-05 1.8 2.3005580357142854e-05 1.8 2.300613839285714e-05 0.0
+ 2.3011718749999998e-05 0.0 2.3012276785714285e-05 1.8 2.30234375e-05 1.8 2.3023995535714283e-05 0.0 2.302957589285714e-05
+ 0.0 2.3030133928571427e-05 1.8 2.3041294642857142e-05 1.8 2.3041852678571425e-05 0.0
+ 2.3047433035714283e-05 0.0 2.304799107142857e-05 1.8 2.3059151785714284e-05 1.8 2.305970982142857e-05 0.0
+ 2.306529017857143e-05 0.0 2.3065848214285712e-05 1.8 2.3077008928571427e-05 1.8 2.3077566964285713e-05 0.0
+ 2.3082589285714284e-05 0.0 2.308314732142857e-05 1.8 2.3095424107142856e-05 1.8 2.3095982142857143e-05 0.0
+ 2.3100446428571426e-05 0.0 2.3101004464285713e-05 1.8 2.3113281249999998e-05 1.8 2.3113839285714285e-05 0.0
+ 2.311830357142857e-05 0.0 2.3118861607142856e-05 1.8 2.313113839285714e-05 1.8 2.3131696428571427e-05 0.0
+ 2.313616071428571e-05 0.0 2.3136718749999998e-05 1.8 2.3148995535714283e-05 1.8 2.314955357142857e-05 0.0
+ 2.3154017857142857e-05 0.0 2.315457589285714e-05 1.8 2.316685267857143e-05 1.8 2.3167410714285712e-05 0.0 2.3171875e-05
+ 0.0 2.3172433035714282e-05 1.8 2.318470982142857e-05 1.8 2.3185267857142854e-05 0.0
+ 2.318973214285714e-05 0.0 2.3190290178571428e-05 1.8 2.3202566964285713e-05 1.8 2.3203125e-05 0.0 2.3207589285714284e-05
+ 0.0 2.320814732142857e-05 1.8 2.3220424107142855e-05 1.8 2.3220982142857142e-05 0.0
+ 2.3225446428571426e-05 0.0 2.3226004464285713e-05 1.8 2.3238281249999998e-05 1.8 2.3238839285714285e-05 0.0
+ 2.324330357142857e-05 0.0 2.3243861607142855e-05 1.8 2.325613839285714e-05 1.8 2.3256696428571427e-05 0.0
+ 2.3261160714285714e-05 0.0 2.3261718749999997e-05 1.8 2.3273995535714282e-05 1.8 2.327455357142857e-05 0.0
+ 2.3279017857142856e-05 0.0 2.327957589285714e-05 1.8 2.3291852678571428e-05 1.8 2.329241071428571e-05 0.0 2.3296875e-05
+ 0.0 2.3297433035714286e-05 1.8 2.330970982142857e-05 1.8 2.3310267857142854e-05 0.0
+ 2.331473214285714e-05 0.0 2.3315290178571428e-05 1.8 2.3327566964285713e-05 1.8 2.3328125e-05 0.0 2.3332589285714283e-05
+ 0.0 2.333314732142857e-05 1.8 2.3345424107142855e-05 1.8 2.3345982142857142e-05 0.0
+ 2.3350446428571426e-05 0.0 2.3351004464285712e-05 1.8 2.3363281249999997e-05 1.8 2.3363839285714284e-05 0.0
+ 2.336830357142857e-05 0.0 2.3368861607142855e-05 1.8 2.338113839285714e-05 1.8 2.3381696428571426e-05 0.0
+ 2.3386160714285714e-05 0.0 2.3386718749999997e-05 1.8 2.3398995535714285e-05 1.8 2.339955357142857e-05 0.0
+ 2.3404017857142856e-05 0.0 2.3404575892857143e-05 1.8 2.3416852678571428e-05 1.8 2.341741071428571e-05 0.0 2.3421875e-05
+ 0.0 2.3422433035714285e-05 1.8 2.343470982142857e-05 1.8 2.3435267857142857e-05 0.0
+ 2.343973214285714e-05 0.0 2.3440290178571427e-05 1.8 2.3452566964285712e-05 1.8 2.3453125e-05 0.0 2.3457589285714283e-05
+ 0.0 2.345814732142857e-05 1.8 2.3470424107142855e-05 1.8 2.347098214285714e-05 0.0
+ 2.3475446428571425e-05 0.0 2.3476004464285712e-05 1.8 2.3488281249999997e-05 1.8 2.3488839285714284e-05 0.0
+ 2.349330357142857e-05 0.0 2.3493861607142854e-05 1.8 2.3506138392857143e-05 1.8 2.3506696428571426e-05 0.0
+ 2.3511160714285713e-05 0.0 2.3511718749999997e-05 1.8 2.3523995535714285e-05 1.8 2.352455357142857e-05 0.0
+ 2.3529017857142856e-05 0.0 2.3529575892857142e-05 1.8 2.3541852678571427e-05 1.8 2.3542410714285714e-05 0.0
+ 2.3546874999999998e-05 0.0 2.3547433035714285e-05 1.8 2.355970982142857e-05 1.8 2.3560267857142857e-05 0.0
+ 2.356473214285714e-05 0.0 2.3565290178571427e-05 1.8 2.3577566964285712e-05 1.8 2.3578125e-05 0.0 2.3582589285714283e-05
+ 0.0 2.358314732142857e-05 1.8 2.3595424107142854e-05 1.8 2.359598214285714e-05 0.0
+ 2.360044642857143e-05 0.0 2.3601004464285712e-05 1.8 2.3613281249999997e-05 1.8 2.3613839285714283e-05 0.0
+ 2.361830357142857e-05 0.0 2.3618861607142854e-05 1.8 2.3631138392857142e-05 1.8 2.3631696428571426e-05 0.0
+ 2.3636160714285713e-05 0.0 2.363671875e-05 1.8 2.3648995535714285e-05 1.8 2.3649553571428568e-05 0.0
+ 2.3654017857142855e-05 0.0 2.3654575892857142e-05 1.8 2.3666852678571427e-05 1.8 2.3667410714285714e-05 0.0
+ 2.3671874999999998e-05 0.0 2.3672433035714284e-05 1.8 2.368470982142857e-05 1.8 2.3685267857142856e-05 0.0
+ 2.368973214285714e-05 0.0 2.3690290178571427e-05 1.8 2.3702566964285712e-05 1.8 2.3703125e-05 0.0 2.3707589285714282e-05
+ 0.0 2.370814732142857e-05 1.8 2.3720424107142854e-05 1.8 2.372098214285714e-05 0.0
+ 2.3725446428571428e-05 0.0 2.372600446428571e-05 1.8 2.373828125e-05 1.8 2.3738839285714283e-05 0.0 2.374330357142857e-05
+ 0.0 2.3743861607142854e-05 1.8 2.3756138392857142e-05 1.8 2.3756696428571425e-05 0.0
+ 2.3761160714285713e-05 0.0 2.376171875e-05 1.8 2.3773995535714284e-05 1.8 2.377455357142857e-05 0.0 2.3779017857142855e-05
+ 0.0 2.3779575892857142e-05 1.8 2.3791852678571427e-05 1.8 2.3792410714285713e-05 0.0
+ 2.3796874999999997e-05 0.0 2.3797433035714284e-05 1.8 2.380970982142857e-05 1.8 2.3810267857142856e-05 0.0
+ 2.381473214285714e-05 0.0 2.3815290178571426e-05 1.8 2.382756696428571e-05 1.8 2.3828124999999998e-05 0.0
+ 2.3832589285714285e-05 0.0 2.383314732142857e-05 1.8 2.3845424107142857e-05 1.8 2.384598214285714e-05 0.0
+ 2.3850446428571428e-05 0.0 2.385100446428571e-05 1.8 2.386328125e-05 1.8 2.3863839285714283e-05 0.0 2.386830357142857e-05
+ 0.0 2.3868861607142857e-05 1.8 2.3881138392857142e-05 1.8 2.388169642857143e-05 0.0
+ 2.3886160714285712e-05 0.0 2.388671875e-05 1.8 2.3898995535714284e-05 1.8 2.389955357142857e-05 0.0 2.3904017857142855e-05
+ 0.0 2.390457589285714e-05 1.8 2.3916852678571426e-05 1.8 2.3917410714285713e-05 0.0
+ 2.3921874999999997e-05 0.0 2.3922433035714284e-05 1.8 2.393470982142857e-05 1.8 2.3935267857142855e-05 0.0
+ 2.3939732142857143e-05 0.0 2.3940290178571426e-05 1.8 2.395256696428571e-05 1.8 2.3953124999999998e-05 0.0
+ 2.3957589285714285e-05 0.0 2.395814732142857e-05 1.8 2.3970424107142857e-05 1.8 2.397098214285714e-05 0.0
+ 2.3975446428571427e-05 0.0 2.3976004464285714e-05 1.8 2.398828125e-05 1.8 2.3988839285714282e-05 0.0 2.399330357142857e-05
+ 0.0 2.3993861607142856e-05 1.8 2.400613839285714e-05 1.8 2.4006696428571428e-05 0.0
+ 2.4011160714285712e-05 0.0 2.401171875e-05 1.8 2.4023995535714284e-05 1.8 2.402455357142857e-05 0.0 2.4029017857142854e-05
+ 0.0 2.402957589285714e-05 1.8 2.4041852678571426e-05 1.8 2.4042410714285713e-05 0.0
+ 2.4046874999999997e-05 0.0 2.4047433035714283e-05 1.8 2.405970982142857e-05 1.8 2.4060267857142855e-05 0.0
+ 2.4064732142857142e-05 0.0 2.4065290178571426e-05 1.8 2.4077566964285714e-05 1.8 2.4078124999999997e-05 0.0
+ 2.4082589285714285e-05 0.0 2.4083147321428568e-05 1.8 2.4095424107142856e-05 1.8 2.409598214285714e-05 0.0
+ 2.4100446428571427e-05 0.0 2.4101004464285714e-05 1.8 2.411328125e-05 1.8 2.4113839285714285e-05 0.0 2.411830357142857e-05
+ 0.0 2.4118861607142856e-05 1.8 2.413113839285714e-05 1.8 2.4131696428571428e-05 0.0
+ 2.413616071428571e-05 0.0 2.413671875e-05 1.8 2.4148995535714283e-05 1.8 2.414955357142857e-05 0.0 2.4154017857142854e-05
+ 0.0 2.415457589285714e-05 1.8 2.4166852678571426e-05 1.8 2.4167410714285712e-05 0.0 2.4171875e-05 0.0
+ 2.4172433035714283e-05 1.8 2.418470982142857e-05 1.8 2.4185267857142855e-05 0.0 2.4189732142857142e-05 0.0
+ 2.4190290178571425e-05 1.8 2.4202566964285714e-05 1.8 2.4203124999999997e-05 0.0 2.4207589285714284e-05 0.0
+ 2.420814732142857e-05 1.8 2.4220424107142856e-05 1.8 2.4220982142857143e-05 0.0 2.4225446428571427e-05 0.0
+ 2.4226004464285713e-05 1.8 2.423828125e-05 1.8 2.4238839285714285e-05 0.0 2.424330357142857e-05 0.0 2.4243861607142856e-05
+ 1.8 2.425613839285714e-05 1.8 2.4256696428571427e-05 0.0 2.426116071428571e-05 0.0
+ 2.4261718749999998e-05 1.8 2.4273995535714283e-05 1.8 2.427455357142857e-05 0.0 2.4279017857142857e-05 0.0
+ 2.427957589285714e-05 1.8 2.4291852678571425e-05 1.8 2.4292410714285712e-05 0.0 2.4296875e-05 0.0 2.4297433035714283e-05
+ 1.8 2.430970982142857e-05 1.8 2.4310267857142854e-05 0.0 2.431473214285714e-05 0.0
+ 2.431529017857143e-05 1.8 2.4327566964285713e-05 1.8 2.4328124999999997e-05 0.0 2.4332589285714284e-05 0.0
+ 2.433314732142857e-05 1.8 2.4345424107142856e-05 1.8 2.4345982142857142e-05 0.0 2.4350446428571426e-05 0.0
+ 2.4351004464285713e-05 1.8 2.4363281249999998e-05 1.8 2.4363839285714285e-05 0.0 2.436830357142857e-05 0.0
+ 2.4368861607142855e-05 1.8 2.438113839285714e-05 1.8 2.4381696428571427e-05 0.0 2.438616071428571e-05 0.0
+ 2.4386718749999998e-05 1.8 2.4398995535714283e-05 1.8 2.439955357142857e-05 0.0 2.4404017857142857e-05 0.0
+ 2.440457589285714e-05 1.8 2.441685267857143e-05 1.8 2.4417410714285712e-05 0.0 2.4421875e-05 0.0 2.4422433035714282e-05
+ 1.8 2.443470982142857e-05 1.8 2.4435267857142854e-05 0.0 2.443973214285714e-05 0.0
+ 2.4440290178571428e-05 1.8 2.4452566964285713e-05 1.8 2.4453125e-05 0.0 2.4457589285714284e-05 0.0 2.445814732142857e-05
+ 1.8 2.4470424107142855e-05 1.8 2.4470982142857142e-05 0.0 2.4475446428571426e-05 0.0
+ 2.4476004464285713e-05 1.8 2.4488281249999998e-05 1.8 2.4488839285714284e-05 0.0 2.4493303571428568e-05 0.0
+ 2.4493861607142855e-05 1.8 2.450613839285714e-05 1.8 2.4506696428571427e-05 0.0 2.4511160714285714e-05 0.0
+ 2.4511718749999997e-05 1.8 2.4523995535714282e-05 1.8 2.452455357142857e-05 0.0 2.4529017857142856e-05 0.0
+ 2.452957589285714e-05 1.8 2.4541852678571428e-05 1.8 2.454241071428571e-05 0.0 2.4546875e-05 0.0 2.4547433035714285e-05
+ 1.8 2.455970982142857e-05 1.8 2.4560267857142854e-05 0.0 2.456473214285714e-05 0.0
+ 2.4565290178571428e-05 1.8 2.4577566964285713e-05 1.8 2.4578125e-05 0.0 2.4582589285714283e-05 0.0 2.458314732142857e-05
+ 1.8 2.4595424107142855e-05 1.8 2.4595982142857142e-05 0.0 2.4600446428571426e-05 0.0
+ 2.4601004464285712e-05 1.8 2.4613281249999997e-05 1.8 2.4613839285714284e-05 0.0 2.461830357142857e-05 0.0
+ 2.4618861607142855e-05 1.8 2.463113839285714e-05 1.8 2.4631696428571426e-05 0.0 2.4636160714285714e-05 0.0
+ 2.4636718749999997e-05 1.8 2.4648995535714285e-05 1.8 2.464955357142857e-05 0.0 2.4654017857142856e-05 0.0
+ 2.4654575892857143e-05 1.8 2.4666852678571428e-05 1.8 2.466741071428571e-05 0.0 2.4671874999999998e-05 0.0
+ 2.4672433035714285e-05 1.8 2.468470982142857e-05 1.8 2.4685267857142857e-05 0.0 2.468973214285714e-05 0.0
+ 2.4690290178571427e-05 1.8 2.4702566964285712e-05 1.8 2.4703125e-05 0.0 2.4707589285714283e-05 0.0 2.470814732142857e-05
+ 1.8 2.4720424107142855e-05 1.8 2.472098214285714e-05 0.0 2.4725446428571425e-05 0.0
+ 2.4726004464285712e-05 1.8 2.4738281249999997e-05 1.8 2.4738839285714284e-05 0.0 2.474330357142857e-05 0.0
+ 2.4743861607142854e-05 1.8 2.4756138392857143e-05 1.8 2.4756696428571426e-05 0.0 2.4761160714285713e-05 0.0
+ 2.4761718749999997e-05 1.8 2.4773995535714285e-05 1.8 2.477455357142857e-05 0.0 2.4779017857142856e-05 0.0
+ 2.4779575892857142e-05 1.8 2.4791852678571427e-05 1.8 2.4792410714285714e-05 0.0 2.4796874999999998e-05 0.0
+ 2.4797433035714285e-05 1.8 2.480970982142857e-05 1.8 2.4810267857142856e-05 0.0 2.481473214285714e-05 0.0
+ 2.4815290178571427e-05 1.8 2.4827566964285712e-05 1.8 2.4828125e-05 0.0 2.4832589285714283e-05 0.0 2.483314732142857e-05
+ 1.8 2.4845424107142854e-05 1.8 2.484598214285714e-05 0.0 2.485044642857143e-05 0.0
+ 2.485100446428571e-05 1.8 2.4863281249999997e-05 1.8 2.4863839285714283e-05 0.0 2.486830357142857e-05 0.0
+ 2.4868861607142854e-05 1.8 2.4881138392857142e-05 1.8 2.4881696428571426e-05 0.0 2.4886160714285713e-05 0.0
+ 2.488671875e-05 1.8 2.4898995535714285e-05 1.8 2.4899553571428568e-05 0.0 2.4904017857142855e-05 0.0
+ 2.4904575892857142e-05 1.8 2.4916852678571427e-05 1.8 2.4917410714285714e-05 0.0 2.4922433035714284e-05 0.0
+ 2.492299107142857e-05 1.8 2.4934151785714283e-05 1.8 2.493470982142857e-05 0.0 2.4940290178571427e-05 0.0
+ 2.4940848214285713e-05 1.8 2.4952008928571428e-05 1.8 2.495256696428571e-05 0.0 2.495814732142857e-05 0.0
+ 2.4958705357142856e-05 1.8 2.496986607142857e-05 1.8 2.4970424107142854e-05 0.0 2.497600446428571e-05 0.0
+ 2.4976562499999998e-05 1.8 2.4987723214285713e-05 1.8 2.498828125e-05 0.0 2.4993861607142857e-05 0.0 2.499441964285714e-05
+ 1.8 2.5005580357142855e-05 1.8 2.5006138392857142e-05 0.0 2.501171875e-05 0.0 2.5012276785714283e-05
+ 1.8 2.5023437499999998e-05 1.8 2.5023995535714284e-05 0.0 2.502957589285714e-05 0.0
+ 2.503013392857143e-05 1.8 2.504129464285714e-05 1.8 2.5041852678571427e-05 0.0 2.5047433035714284e-05 0.0
+ 2.504799107142857e-05 1.8 2.5059151785714286e-05 1.8 2.505970982142857e-05 0.0 2.5065290178571426e-05 0.0
+ 2.5065848214285713e-05 1.8 2.5077008928571428e-05 1.8 2.507756696428571e-05 0.0 2.508314732142857e-05 0.0
+ 2.5083705357142855e-05 1.8 2.509486607142857e-05 1.8 2.5095424107142857e-05 0.0 2.510100446428571e-05 0.0
+ 2.5101562499999998e-05 1.8 2.5112723214285713e-05 1.8 2.511328125e-05 0.0 2.5118861607142857e-05 0.0 2.511941964285714e-05
+ 1.8 2.5130580357142855e-05 1.8 2.513113839285714e-05 0.0 2.513671875e-05 0.0 2.5137276785714282e-05 1.8
+ 2.5148437499999997e-05 1.8 2.5148995535714284e-05 0.0 2.515457589285714e-05 0.0 2.5155133928571428e-05 1.8
+ 2.516629464285714e-05 1.8 2.5166852678571426e-05 0.0 2.5172433035714284e-05 0.0 2.517299107142857e-05 1.8
+ 2.5184151785714285e-05 1.8 2.518470982142857e-05 0.0 2.5190290178571426e-05 0.0 2.5190848214285713e-05 1.8
+ 2.5202008928571428e-05 1.8 2.520256696428571e-05 0.0 2.520814732142857e-05 0.0 2.5208705357142855e-05 1.8
+ 2.521986607142857e-05 1.8 2.5220424107142857e-05 0.0 2.5226004464285714e-05 0.0 2.5226562499999997e-05 1.8
+ 2.5237723214285712e-05 1.8 2.523828125e-05 0.0 2.5243861607142856e-05 0.0 2.524441964285714e-05 1.8 2.5255580357142855e-05
+ 1.8 2.525613839285714e-05 0.0 2.526171875e-05 0.0 2.5262276785714285e-05 1.8 2.5273437499999997e-05 1.8
+ 2.5273995535714284e-05 0.0 2.527957589285714e-05 0.0 2.5280133928571428e-05 1.8 2.5291294642857143e-05 1.8
+ 2.5291852678571426e-05 0.0 2.5297433035714283e-05 0.0 2.529799107142857e-05 1.8 2.5309151785714285e-05 1.8
+ 2.5309709821428568e-05 0.0 2.5315290178571426e-05 0.0 2.5315848214285712e-05 1.8 2.5327008928571427e-05 1.8
+ 2.5327566964285714e-05 0.0 2.5333705357142855e-05 0.0 2.533426339285714e-05 1.8 2.5344308035714283e-05 1.8
+ 2.534486607142857e-05 0.0 2.5351562499999997e-05 0.0 2.5352120535714284e-05 1.8 2.5362165178571425e-05 1.8
+ 2.5362723214285712e-05 0.0 2.536941964285714e-05 0.0 2.5369977678571426e-05 1.8 2.538002232142857e-05 1.8
+ 2.5380580357142854e-05 0.0 2.5387276785714285e-05 0.0 2.538783482142857e-05 1.8 2.5397879464285713e-05 1.8 2.53984375e-05
+ 0.0 2.5405133928571427e-05 0.0 2.5405691964285714e-05 1.8 2.5415736607142855e-05 1.8
+ 2.5416294642857142e-05 0.0 2.542299107142857e-05 0.0 2.5423549107142856e-05 1.8 2.5433593749999998e-05 1.8
+ 2.5434151785714285e-05 0.0 2.5440848214285712e-05 0.0 2.544140625e-05 1.8 2.545145089285714e-05 1.8 2.5452008928571427e-05
+ 0.0 2.5458705357142854e-05 0.0 2.545926339285714e-05 1.8 2.5469308035714282e-05 1.8
+ 2.546986607142857e-05 0.0 2.5476562499999997e-05 0.0 2.5477120535714283e-05 1.8 2.5487165178571428e-05 1.8
+ 2.548772321428571e-05 0.0 2.5494419642857142e-05 0.0 2.5494977678571426e-05 1.8 2.550502232142857e-05 1.8
+ 2.5505580357142854e-05 0.0 2.5512276785714285e-05 0.0 2.5512834821428568e-05 1.8 2.5522879464285713e-05 1.8 2.55234375e-05
+ 0.0 2.5530133928571427e-05 0.0 2.5530691964285714e-05 1.8 2.5540736607142855e-05 1.8
+ 2.5541294642857142e-05 0.0 2.554799107142857e-05 0.0 2.5548549107142856e-05 1.8 2.5558593749999997e-05 1.8
+ 2.5559151785714284e-05 0.0 2.556584821428571e-05 0.0 2.556640625e-05 1.8 2.557645089285714e-05 1.8 2.5577008928571426e-05
+ 0.0 2.5583705357142854e-05 0.0 2.558426339285714e-05 1.8 2.5594308035714285e-05 1.8
+ 2.559486607142857e-05 0.0 2.56015625e-05 0.0 2.5602120535714283e-05 1.8 2.5612165178571428e-05 1.8 2.561272321428571e-05
+ 0.0 2.5619419642857142e-05 0.0 2.5619977678571425e-05 1.8 2.563002232142857e-05 1.8
+ 2.5630580357142857e-05 0.0 2.5637276785714284e-05 0.0 2.563783482142857e-05 1.8 2.5647879464285712e-05 1.8 2.56484375e-05
+ 0.0 2.5655133928571427e-05 0.0 2.5655691964285713e-05 1.8 2.5665736607142855e-05 1.8
+ 2.566629464285714e-05 0.0 2.567299107142857e-05 0.0 2.5673549107142856e-05 1.8 2.5683035714285714e-05 1.8
+ 2.5683593749999997e-05 0.0 2.5691406249999998e-05 0.0 2.5691964285714285e-05 1.8 2.5700892857142856e-05 1.8
+ 2.570145089285714e-05 0.0 2.570926339285714e-05 0.0 2.5709821428571427e-05 1.8 2.571875e-05 1.8 2.5719308035714285e-05
+ 0.0 2.5727120535714283e-05 0.0 2.572767857142857e-05 1.8 2.573660714285714e-05 1.8
+ 2.5737165178571427e-05 0.0 2.5744977678571425e-05 0.0 2.5745535714285712e-05 1.8 2.5754464285714283e-05 1.8
+ 2.575502232142857e-05 0.0 2.576283482142857e-05 0.0 2.5763392857142854e-05 1.8 2.5772321428571425e-05 1.8
+ 2.5772879464285712e-05 0.0 2.5780691964285713e-05 0.0 2.5781249999999996e-05 1.8 2.579017857142857e-05 1.8
+ 2.5790736607142854e-05 0.0 2.5798549107142855e-05 0.0 2.5799107142857142e-05 1.8 2.5808035714285713e-05 1.8
+ 2.5808593749999997e-05 0.0 2.5816406249999998e-05 0.0 2.5816964285714285e-05 1.8 2.5825892857142856e-05 1.8
+ 2.5826450892857142e-05 0.0 2.583426339285714e-05 0.0 2.5834821428571427e-05 1.8 2.5843749999999998e-05 1.8
+ 2.5844308035714285e-05 0.0 2.5852120535714282e-05 0.0 2.585267857142857e-05 1.8 2.586160714285714e-05 1.8
+ 2.5862165178571427e-05 0.0 2.5869977678571428e-05 0.0 2.587053571428571e-05 1.8 2.5879464285714283e-05 1.8
+ 2.588002232142857e-05 0.0 2.588783482142857e-05 0.0 2.5888392857142854e-05 1.8 2.589732142857143e-05 1.8
+ 2.5897879464285712e-05 0.0 2.5905691964285713e-05 0.0 2.590625e-05 1.8 2.591517857142857e-05 1.8 2.5915736607142854e-05
+ 0.0 2.5923549107142855e-05 0.0 2.5924107142857142e-05 1.8 2.5933035714285713e-05 1.8 2.593359375e-05
+ 0.0 2.5941406249999997e-05 0.0 2.5941964285714284e-05 1.8 2.5950892857142855e-05 1.8
+ 2.5951450892857142e-05 0.0 2.595926339285714e-05 0.0 2.5959821428571426e-05 1.8 2.5968749999999998e-05 1.8
+ 2.5969308035714284e-05 0.0 2.5977120535714285e-05 0.0 2.597767857142857e-05 1.8 2.598660714285714e-05 1.8
+ 2.5987165178571427e-05 0.0 2.5994977678571428e-05 0.0 2.599553571428571e-05 1.8 2.600390625e-05 1.8 2.6004464285714282e-05
+ 0.0 2.6013392857142857e-05 0.0 2.601395089285714e-05 1.8 2.602176339285714e-05 1.8
+ 2.6022321428571428e-05 0.0 2.603125e-05 0.0 2.6031808035714283e-05 1.8 2.6039620535714284e-05 1.8 2.604017857142857e-05
+ 0.0 2.604910714285714e-05 0.0 2.6049665178571428e-05 1.8 2.6057477678571426e-05 1.8
+ 2.6058035714285713e-05 0.0 2.6066964285714284e-05 0.0 2.606752232142857e-05 1.8 2.6075334821428568e-05 1.8
+ 2.6075892857142855e-05 0.0 2.6084821428571426e-05 0.0 2.6085379464285713e-05 1.8 2.6093191964285714e-05 1.8
+ 2.6093749999999997e-05 0.0 2.610267857142857e-05 0.0 2.6103236607142855e-05 1.8 2.6111049107142856e-05 1.8
+ 2.611160714285714e-05 0.0 2.612053571428571e-05 0.0 2.6121093749999998e-05 1.8 2.612890625e-05 1.8 2.6129464285714285e-05
+ 0.0 2.6138392857142856e-05 0.0 2.613895089285714e-05 1.8 2.614676339285714e-05 1.8
+ 2.6147321428571428e-05 0.0 2.615625e-05 0.0 2.6156808035714282e-05 1.8 2.6164620535714283e-05 1.8 2.616517857142857e-05
+ 0.0 2.617410714285714e-05 0.0 2.6174665178571428e-05 1.8 2.6182477678571426e-05 1.8
+ 2.6183035714285712e-05 0.0 2.6191964285714283e-05 0.0 2.619252232142857e-05 1.8 2.6200334821428568e-05 1.8
+ 2.6200892857142855e-05 0.0 2.6209821428571426e-05 0.0 2.6210379464285713e-05 1.8 2.6218191964285714e-05 1.8
+ 2.6218749999999997e-05 0.0 2.6227678571428568e-05 0.0 2.6228236607142855e-05 1.8 2.6236049107142856e-05 1.8
+ 2.6236607142857143e-05 0.0 2.6245535714285714e-05 0.0 2.6246093749999997e-05 1.8 2.6253906249999998e-05 1.8
+ 2.6254464285714285e-05 0.0 2.6263392857142856e-05 0.0 2.626395089285714e-05 1.8 2.627176339285714e-05 1.8
+ 2.6272321428571427e-05 0.0 2.628125e-05 0.0 2.6281808035714285e-05 1.8 2.6289620535714283e-05 1.8 2.629017857142857e-05
+ 0.0 2.629910714285714e-05 0.0 2.6299665178571428e-05 1.8 2.6307477678571425e-05 1.8
+ 2.6308035714285712e-05 0.0 2.6316964285714283e-05 0.0 2.631752232142857e-05 1.8 2.6324776785714284e-05 1.8
+ 2.632533482142857e-05 0.0 2.6335379464285712e-05 0.0 2.63359375e-05 1.8 2.6342633928571426e-05 1.8 2.6343191964285713e-05
+ 0.0 2.6353236607142855e-05 0.0 2.635379464285714e-05 1.8 2.636049107142857e-05 1.8
+ 2.6361049107142856e-05 0.0 2.6371093749999997e-05 0.0 2.6371651785714284e-05 1.8 2.637834821428571e-05 1.8
+ 2.6378906249999998e-05 0.0 2.6388950892857143e-05 0.0 2.6389508928571426e-05 1.8 2.6396205357142857e-05 1.8
+ 2.639676339285714e-05 0.0 2.6406808035714285e-05 0.0 2.6407366071428568e-05 1.8 2.64140625e-05 1.8 2.6414620535714283e-05
+ 0.0 2.6424665178571427e-05 0.0 2.6425223214285714e-05 1.8 2.643191964285714e-05 1.8
+ 2.6432477678571428e-05 0.0 2.644252232142857e-05 0.0 2.6443080357142856e-05 1.8 2.6449776785714284e-05 1.8
+ 2.645033482142857e-05 0.0 2.6460379464285712e-05 0.0 2.64609375e-05 1.8 2.6467633928571426e-05 1.8 2.6468191964285713e-05
+ 0.0 2.6478236607142854e-05 0.0 2.647879464285714e-05 1.8 2.648549107142857e-05 1.8
+ 2.6486049107142855e-05 0.0 2.6496093749999996e-05 0.0 2.6496651785714283e-05 1.8 2.650334821428571e-05 1.8
+ 2.6503906249999998e-05 0.0 2.6513950892857142e-05 0.0 2.6514508928571426e-05 1.8 2.6521205357142856e-05 1.8
+ 2.652176339285714e-05 0.0 2.6531808035714285e-05 0.0 2.6532366071428568e-05 1.8 2.65390625e-05 1.8 2.6539620535714282e-05
+ 0.0 2.6549665178571427e-05 0.0 2.6550223214285714e-05 1.8 2.655691964285714e-05 1.8
+ 2.6557477678571428e-05 0.0 2.656752232142857e-05 0.0 2.6568080357142856e-05 1.8 2.6574776785714283e-05 1.8
+ 2.657533482142857e-05 0.0 2.658537946428571e-05 0.0 2.6585937499999998e-05 1.8 2.6592633928571426e-05 1.8
+ 2.6593191964285713e-05 0.0 2.6603236607142854e-05 0.0 2.660379464285714e-05 1.8 2.6610491071428568e-05 1.8
+ 2.6611049107142855e-05 0.0 2.662109375e-05 0.0 2.6621651785714283e-05 1.8 2.6628348214285714e-05 1.8
+ 2.6628906249999997e-05 0.0 2.6638950892857142e-05 0.0 2.6639508928571425e-05 1.8 2.6646205357142856e-05 1.8
+ 2.664676339285714e-05 0.0 2.6656808035714284e-05 0.0 2.665736607142857e-05 1.8 2.66640625e-05 1.8 2.6664620535714285e-05
+ 0.0 2.6675223214285713e-05 0.0 2.6675781249999997e-05 1.8 2.6681361607142854e-05 1.8
+ 2.668191964285714e-05 0.0 2.6693080357142856e-05 0.0 2.6693638392857142e-05 1.8 2.669921875e-05 1.8
+ 2.6699776785714283e-05 0.0 2.6710937499999998e-05 0.0 2.6711495535714285e-05 1.8 2.6717075892857142e-05 1.8
+ 2.6717633928571425e-05 0.0 2.672879464285714e-05 0.0 2.6729352678571427e-05 1.8 2.6734933035714284e-05 1.8
+ 2.673549107142857e-05 0.0 2.6746651785714283e-05 0.0 2.674720982142857e-05 1.8 2.6752790178571427e-05 1.8
+ 2.6753348214285713e-05 0.0 2.6764508928571428e-05 0.0 2.676506696428571e-05 1.8 2.677064732142857e-05 1.8
+ 2.6771205357142856e-05 0.0 2.678236607142857e-05 0.0 2.6782924107142854e-05 1.8 2.678850446428571e-05 1.8
+ 2.6789062499999998e-05 0.0 2.6800223214285713e-05 0.0 2.680078125e-05 1.8 2.6806361607142854e-05 1.8 2.680691964285714e-05
+ 0.0 2.6818080357142855e-05 0.0 2.6818638392857142e-05 1.8 2.682421875e-05 1.8 2.6824776785714283e-05
+ 0.0 2.6835937499999998e-05 0.0 2.6836495535714284e-05 1.8 2.6842075892857142e-05 1.8
+ 2.6842633928571425e-05 0.0 2.685379464285714e-05 0.0 2.6854352678571427e-05 1.8 2.6859933035714284e-05 1.8
+ 2.686049107142857e-05 0.0 2.6871651785714282e-05 0.0 2.687220982142857e-05 1.8 2.6877790178571426e-05 1.8
+ 2.6878348214285713e-05 0.0 2.6889508928571428e-05 0.0 2.689006696428571e-05 1.8 2.689564732142857e-05 1.8
+ 2.6896205357142855e-05 0.0 2.690736607142857e-05 0.0 2.6907924107142854e-05 1.8 2.691350446428571e-05 1.8
+ 2.6914062499999998e-05 0.0 2.6925223214285713e-05 0.0 2.692578125e-05 1.8 2.6931361607142857e-05 1.8 2.693191964285714e-05
+ 0.0 2.6943080357142855e-05 0.0 2.694363839285714e-05 1.8 2.694921875e-05 1.8 2.6949776785714282e-05 0.0
+ 2.6960937499999997e-05 0.0 2.6961495535714284e-05 1.8 2.696707589285714e-05 1.8 2.6967633928571428e-05 0.0
+ 2.697879464285714e-05 0.0 2.6979352678571426e-05 1.8 2.6984933035714284e-05 1.8 2.698549107142857e-05 0.0
+ 2.6996651785714285e-05 0.0 2.699720982142857e-05 1.8 2.7002790178571426e-05 1.8 2.7003348214285713e-05 0.0
+ 2.7014508928571428e-05 0.0 2.701506696428571e-05 1.8 2.702064732142857e-05 1.8 2.7021205357142855e-05 0.0
+ 2.703236607142857e-05 0.0 2.7032924107142857e-05 1.8 2.7038504464285714e-05 1.8 2.7039062499999997e-05 0.0
+ 2.7050223214285712e-05 0.0 2.705078125e-05 1.8 2.7056361607142856e-05 1.8 2.705691964285714e-05 0.0 2.7068080357142855e-05
+ 0.0 2.706863839285714e-05 1.8 2.707421875e-05 1.8 2.7074776785714285e-05 0.0 2.7086495535714284e-05 0.0
+ 2.708705357142857e-05 1.8 2.7091517857142854e-05 1.8 2.709207589285714e-05 0.0 2.7104352678571426e-05 0.0
+ 2.7104910714285713e-05 1.8 2.7109374999999997e-05 1.8 2.7109933035714283e-05 0.0 2.7122209821428568e-05 0.0
+ 2.7122767857142855e-05 1.8 2.7127232142857142e-05 1.8 2.7127790178571426e-05 0.0 2.7140066964285714e-05 0.0
+ 2.7140624999999997e-05 1.8 2.7145089285714285e-05 1.8 2.7145647321428568e-05 0.0 2.7157924107142856e-05 0.0
+ 2.715848214285714e-05 1.8 2.7162946428571427e-05 1.8 2.7163504464285714e-05 0.0 2.717578125e-05 0.0
+ 2.7176339285714285e-05 1.8 2.718080357142857e-05 1.8 2.7181361607142856e-05 0.0 2.719363839285714e-05 0.0
+ 2.7194196428571428e-05 1.8 2.719866071428571e-05 1.8 2.719921875e-05 0.0 2.7211495535714283e-05 0.0 2.721205357142857e-05
+ 1.8 2.7216517857142854e-05 1.8 2.721707589285714e-05 0.0 2.7229352678571426e-05 0.0
+ 2.7229910714285712e-05 1.8 2.7234375e-05 1.8 2.7234933035714283e-05 0.0 2.7247209821428568e-05 0.0 2.7247767857142855e-05
+ 1.8 2.7252232142857142e-05 1.8 2.7252790178571425e-05 0.0 2.7265066964285714e-05 0.0
+ 2.7265624999999997e-05 1.8 2.7270089285714284e-05 1.8 2.727064732142857e-05 0.0 2.7282924107142856e-05 0.0
+ 2.728348214285714e-05 1.8 2.7287946428571427e-05 1.8 2.7288504464285713e-05 0.0 2.7300781249999998e-05 0.0
+ 2.7301339285714285e-05 1.8 2.730580357142857e-05 1.8 2.7306361607142856e-05 0.0 2.731863839285714e-05 0.0
+ 2.7319196428571427e-05 1.8 2.732366071428571e-05 1.8 2.7324218749999998e-05 0.0 2.7336495535714283e-05 0.0
+ 2.733705357142857e-05 1.8 2.7341517857142854e-05 1.8 2.734207589285714e-05 0.0 2.7354352678571425e-05 0.0
+ 2.7354910714285712e-05 1.8 2.7359375e-05 1.8 2.7359933035714283e-05 0.0 2.737220982142857e-05 0.0 2.7372767857142854e-05
+ 1.8 2.737723214285714e-05 1.8 2.7377790178571425e-05 0.0 2.7390066964285713e-05 0.0
+ 2.7390624999999997e-05 1.8 2.7395089285714284e-05 1.8 2.739564732142857e-05 0.0 2.7407924107142856e-05 0.0
+ 2.7408482142857142e-05 1.8 2.7412946428571426e-05 1.8 2.7413504464285713e-05 0.0 2.7425781249999998e-05 0.0
+ 2.7426339285714285e-05 1.8 2.743080357142857e-05 1.8 2.7431361607142855e-05 0.0 2.744363839285714e-05 0.0
+ 2.7444196428571427e-05 1.8 2.744866071428571e-05 1.8 2.7449218749999998e-05 0.0 2.7461495535714283e-05 0.0
+ 2.746205357142857e-05 1.8 2.7466517857142857e-05 1.8 2.746707589285714e-05 0.0 2.7479352678571428e-05 0.0
+ 2.747991071428571e-05 1.8 2.7484375e-05 1.8 2.7484933035714282e-05 0.0 2.749720982142857e-05 0.0 2.7497767857142854e-05
+ 1.8 2.750223214285714e-05 1.8 2.7502790178571428e-05 0.0 2.7515066964285713e-05 0.0 2.7515625e-05 1.8
+ 2.7520089285714284e-05 1.8 2.752064732142857e-05 0.0 2.7532924107142855e-05 0.0 2.7533482142857142e-05 1.8
+ 2.7537946428571426e-05 1.8 2.7538504464285713e-05 0.0 2.7550781249999998e-05 0.0 2.7551339285714284e-05 1.8
+ 2.7555803571428568e-05 1.8 2.7556361607142855e-05 0.0 2.756863839285714e-05 0.0 2.7569196428571427e-05 1.8
+ 2.7573660714285714e-05 1.8 2.7574218749999997e-05 0.0 2.7586495535714282e-05 0.0 2.758705357142857e-05 1.8
+ 2.7591517857142856e-05 1.8 2.759207589285714e-05 0.0 2.7604352678571428e-05 0.0 2.760491071428571e-05 1.8 2.7609375e-05
+ 1.8 2.7609933035714285e-05 0.0 2.762220982142857e-05 0.0 2.7622767857142854e-05 1.8
+ 2.762723214285714e-05 1.8 2.7627790178571428e-05 0.0 2.7640066964285713e-05 0.0 2.7640625e-05 1.8 2.7645089285714283e-05
+ 1.8 2.764564732142857e-05 0.0 2.7657924107142855e-05 0.0 2.765848214285714e-05 1.8
+ 2.7662946428571426e-05 1.8 2.7663504464285712e-05 0.0 2.7675781249999997e-05 0.0 2.7676339285714284e-05 1.8
+ 2.7680803571428568e-05 1.8 2.7681361607142855e-05 0.0 2.769363839285714e-05 0.0 2.7694196428571426e-05 1.8
+ 2.7698660714285714e-05 1.8 2.7699218749999997e-05 0.0 2.7711495535714285e-05 0.0 2.771205357142857e-05 1.8
+ 2.7716517857142856e-05 1.8 2.771707589285714e-05 0.0 2.7729352678571428e-05 0.0 2.772991071428571e-05 1.8
+ 2.7734374999999998e-05 1.8 2.7734933035714285e-05 0.0 2.774720982142857e-05 0.0 2.7747767857142857e-05 1.8
+ 2.775223214285714e-05 1.8 2.7752790178571427e-05 0.0 2.7765066964285712e-05 0.0 2.7765625e-05 1.8 2.7770089285714283e-05
+ 1.8 2.777064732142857e-05 0.0 2.7782924107142855e-05 0.0 2.778348214285714e-05 1.8
+ 2.7787946428571425e-05 1.8 2.7788504464285712e-05 0.0 2.7800781249999997e-05 0.0 2.7801339285714284e-05 1.8
+ 2.780580357142857e-05 1.8 2.7806361607142854e-05 0.0 2.781863839285714e-05 0.0 2.7819196428571426e-05 1.8
+ 2.7823660714285713e-05 1.8 2.7824218749999997e-05 0.0 2.7836495535714285e-05 0.0 2.7837053571428568e-05 1.8
+ 2.7841517857142856e-05 1.8 2.7842075892857142e-05 0.0 2.7854352678571427e-05 0.0 2.7854910714285714e-05 1.8
+ 2.7859374999999998e-05 1.8 2.7859933035714285e-05 0.0 2.787220982142857e-05 0.0 2.7872767857142856e-05 1.8
+ 2.787723214285714e-05 1.8 2.7877790178571427e-05 0.0 2.7890066964285712e-05 0.0 2.7890625e-05 1.8 2.7895089285714283e-05
+ 1.8 2.789564732142857e-05 0.0 2.7907924107142854e-05 0.0 2.790848214285714e-05 1.8
+ 2.7912946428571428e-05 1.8 2.791350446428571e-05 0.0 2.7925781249999997e-05 0.0 2.7926339285714283e-05 1.8
+ 2.793080357142857e-05 1.8 2.7931361607142854e-05 0.0 2.7943638392857142e-05 0.0 2.7944196428571426e-05 1.8
+ 2.7948660714285713e-05 1.8 2.794921875e-05 0.0 2.7961495535714285e-05 0.0 2.7962053571428568e-05 1.8
+ 2.7966517857142855e-05 1.8 2.7967075892857142e-05 0.0 2.7979352678571427e-05 0.0 2.7979910714285714e-05 1.8
+ 2.7984374999999998e-05 1.8 2.7984933035714284e-05 0.0 2.799720982142857e-05 0.0 2.7997767857142856e-05 1.8
+ 2.800223214285714e-05 1.8 2.8002790178571427e-05 0.0 2.801506696428571e-05 0.0 2.8015624999999998e-05 1.8
+ 2.8020089285714282e-05 1.8 2.802064732142857e-05 0.0 2.8032924107142854e-05 0.0 2.803348214285714e-05 1.8
+ 2.8037946428571428e-05 1.8 2.803850446428571e-05 0.0 2.805078125e-05 0.0 2.8051339285714283e-05 1.8 2.805580357142857e-05
+ 1.8 2.8056361607142854e-05 0.0 2.8068638392857142e-05 0.0 2.8069196428571425e-05 1.8
+ 2.8073660714285713e-05 1.8 2.807421875e-05 0.0 2.8086495535714284e-05 0.0 2.808705357142857e-05 1.8 2.8091517857142855e-05
+ 1.8 2.809207589285714e-05 0.0 2.8104352678571427e-05 0.0 2.8104910714285713e-05 1.8
+ 2.8109374999999997e-05 1.8 2.8109933035714284e-05 0.0 2.812220982142857e-05 0.0 2.8122767857142856e-05 1.8
+ 2.812723214285714e-05 1.8 2.8127790178571426e-05 0.0 2.814006696428571e-05 0.0 2.8140624999999998e-05 1.8
+ 2.8145089285714285e-05 1.8 2.814564732142857e-05 0.0 2.8157924107142853e-05 0.0 2.815848214285714e-05 1.8
+ 2.8162946428571428e-05 1.8 2.816350446428571e-05 0.0 2.817578125e-05 0.0 2.8176339285714283e-05 1.8 2.818080357142857e-05
+ 1.8 2.8181361607142857e-05 0.0 2.819363839285714e-05 0.0 2.8194196428571425e-05 1.8
+ 2.8198660714285712e-05 1.8 2.819921875e-05 0.0 2.8211495535714284e-05 0.0 2.821205357142857e-05 1.8 2.8216517857142854e-05
+ 1.8 2.821707589285714e-05 0.0 2.8229352678571426e-05 0.0 2.8229910714285713e-05 1.8
+ 2.8234374999999997e-05 1.8 2.8234933035714284e-05 0.0 2.824720982142857e-05 0.0 2.8247767857142855e-05 1.8
+ 2.8252232142857143e-05 1.8 2.8252790178571426e-05 0.0 2.826506696428571e-05 0.0 2.8265624999999998e-05 1.8
+ 2.8270089285714285e-05 1.8 2.8270647321428568e-05 0.0 2.8282924107142857e-05 0.0 2.828348214285714e-05 1.8
+ 2.8287946428571427e-05 1.8 2.8288504464285714e-05 0.0 2.830078125e-05 0.0 2.8301339285714282e-05 1.8 2.830580357142857e-05
+ 1.8 2.8306361607142856e-05 0.0 2.831863839285714e-05 0.0 2.8319196428571428e-05 1.8
+ 2.8323660714285712e-05 1.8 2.832421875e-05 0.0 2.8336495535714283e-05 0.0 2.833705357142857e-05 1.8 2.8341517857142854e-05
+ 1.8 2.834207589285714e-05 0.0 2.8354352678571426e-05 0.0 2.8354910714285713e-05 1.8
+ 2.8359374999999996e-05 1.8 2.8359933035714283e-05 0.0 2.8372209821428568e-05 0.0 2.8372767857142855e-05 1.8
+ 2.8377232142857142e-05 1.8 2.8377790178571426e-05 0.0 2.8390066964285714e-05 0.0 2.8390624999999997e-05 1.8
+ 2.8395089285714284e-05 1.8 2.8395647321428568e-05 0.0 2.8407924107142856e-05 0.0 2.840848214285714e-05 1.8
+ 2.8412946428571427e-05 1.8 2.8413504464285714e-05 0.0 2.842578125e-05 0.0 2.8426339285714285e-05 1.8 2.843080357142857e-05
+ 1.8 2.8431361607142856e-05 0.0 2.844363839285714e-05 0.0 2.8444196428571428e-05 1.8
+ 2.844866071428571e-05 1.8 2.8449218749999998e-05 0.0 2.8461495535714283e-05 0.0 2.846205357142857e-05 1.8
+ 2.8466517857142854e-05 1.8 2.846707589285714e-05 0.0 2.8479352678571425e-05 0.0 2.8479910714285712e-05 1.8 2.8484375e-05
+ 1.8 2.8484933035714283e-05 0.0 2.8497209821428568e-05 0.0 2.8497767857142855e-05 1.8
+ 2.8502232142857142e-05 1.8 2.8502790178571425e-05 0.0 2.8515066964285713e-05 0.0 2.8515624999999997e-05 1.8
+ 2.8520089285714284e-05 1.8 2.852064732142857e-05 0.0 2.8532924107142856e-05 0.0 2.853348214285714e-05 1.8
+ 2.8537946428571426e-05 1.8 2.8538504464285713e-05 0.0 2.8550781249999998e-05 0.0 2.8551339285714285e-05 1.8
+ 2.855580357142857e-05 1.8 2.8556361607142856e-05 0.0 2.856863839285714e-05 0.0 2.8569196428571427e-05 1.8
+ 2.857366071428571e-05 1.8 2.8574218749999998e-05 0.0 2.8586495535714283e-05 0.0 2.858705357142857e-05 1.8
+ 2.8591517857142853e-05 1.8 2.859207589285714e-05 0.0 2.8604352678571425e-05 0.0 2.8604910714285712e-05 1.8 2.8609375e-05
+ 1.8 2.8609933035714283e-05 0.0 2.862220982142857e-05 0.0 2.8622767857142854e-05 1.8
+ 2.862723214285714e-05 1.8 2.8627790178571425e-05 0.0 2.8640066964285713e-05 0.0 2.8640624999999997e-05 1.8
+ 2.8645089285714284e-05 1.8 2.864564732142857e-05 0.0 2.8657924107142855e-05 0.0 2.8658482142857142e-05 1.8
+ 2.8662946428571426e-05 1.8 2.8663504464285713e-05 0.0 2.8675781249999998e-05 0.0 2.8676339285714285e-05 1.8
+ 2.868080357142857e-05 1.8 2.8681361607142855e-05 0.0 2.869363839285714e-05 0.0 2.8694196428571427e-05 1.8
+ 2.869866071428571e-05 1.8 2.8699218749999998e-05 0.0 2.8711495535714282e-05 0.0 2.871205357142857e-05 1.8
+ 2.8716517857142856e-05 1.8 2.871707589285714e-05 0.0 2.8729352678571428e-05 0.0 2.872991071428571e-05 1.8 2.8734375e-05
+ 1.8 2.8734933035714282e-05 0.0 2.874720982142857e-05 0.0 2.8747767857142854e-05 1.8
+ 2.875223214285714e-05 1.8 2.8752790178571428e-05 0.0 2.8765066964285713e-05 0.0 2.8765625e-05 1.8 2.8770089285714283e-05
+ 1.8 2.877064732142857e-05 0.0 2.8782924107142855e-05 0.0 2.8783482142857142e-05 1.8
+ 2.8787946428571426e-05 1.8 2.8788504464285713e-05 0.0 2.8800781249999997e-05 0.0 2.8801339285714284e-05 1.8
+ 2.8805803571428568e-05 1.8 2.8806361607142855e-05 0.0 2.881863839285714e-05 0.0 2.8819196428571427e-05 1.8
+ 2.8823660714285714e-05 1.8 2.8824218749999997e-05 0.0 2.8836495535714282e-05 0.0 2.883705357142857e-05 1.8
+ 2.8841517857142856e-05 1.8 2.884207589285714e-05 0.0 2.8854352678571428e-05 0.0 2.885491071428571e-05 1.8 2.8859375e-05
+ 1.8 2.8859933035714285e-05 0.0 2.887220982142857e-05 0.0 2.8872767857142853e-05 1.8
+ 2.887723214285714e-05 1.8 2.8877790178571428e-05 0.0 2.8890066964285712e-05 0.0 2.8890625e-05 1.8 2.8895089285714283e-05
+ 1.8 2.889564732142857e-05 0.0 2.8907924107142855e-05 0.0 2.890848214285714e-05 1.8
+ 2.8912946428571425e-05 1.8 2.8913504464285712e-05 0.0 2.8925223214285714e-05 0.0 2.8925781249999997e-05 1.8
+ 2.8931361607142854e-05 1.8 2.893191964285714e-05 0.0 2.8943080357142856e-05 0.0 2.894363839285714e-05 1.8
+ 2.8949218749999997e-05 1.8 2.8949776785714284e-05 0.0 2.89609375e-05 0.0 2.8961495535714285e-05 1.8 2.896707589285714e-05
+ 1.8 2.8967633928571426e-05 0.0 2.897879464285714e-05 0.0 2.8979352678571427e-05 1.8
+ 2.8984933035714285e-05 1.8 2.8985491071428568e-05 0.0 2.8996651785714283e-05 0.0 2.899720982142857e-05 1.8
+ 2.9002790178571427e-05 1.8 2.900334821428571e-05 0.0 2.9014508928571425e-05 0.0 2.9015066964285712e-05 1.8
+ 2.902064732142857e-05 1.8 2.9021205357142856e-05 0.0 2.9032366071428568e-05 0.0 2.9032924107142854e-05 1.8
+ 2.9038504464285712e-05 1.8 2.90390625e-05 0.0 2.9050223214285713e-05 0.0 2.9050781249999997e-05 1.8 2.9056361607142854e-05
+ 1.8 2.905691964285714e-05 0.0 2.9068080357142856e-05 0.0 2.9068638392857142e-05 1.8
+ 2.9074218749999996e-05 1.8 2.9074776785714283e-05 0.0 2.9085937499999998e-05 0.0 2.9086495535714285e-05 1.8
+ 2.9092075892857142e-05 1.8 2.9092633928571426e-05 0.0 2.910379464285714e-05 0.0 2.9104352678571427e-05 1.8
+ 2.9109933035714285e-05 1.8 2.9110491071428568e-05 0.0 2.9121651785714283e-05 0.0 2.912220982142857e-05 1.8
+ 2.9127790178571427e-05 1.8 2.9128348214285714e-05 0.0 2.9139508928571425e-05 0.0 2.9140066964285712e-05 1.8
+ 2.914564732142857e-05 1.8 2.9146205357142856e-05 0.0 2.915736607142857e-05 0.0 2.9157924107142854e-05 1.8
+ 2.916350446428571e-05 1.8 2.9164062499999998e-05 0.0 2.9175223214285713e-05 0.0 2.9175781249999996e-05 1.8
+ 2.9181361607142854e-05 1.8 2.918191964285714e-05 0.0 2.9193080357142855e-05 0.0 2.9193638392857142e-05 1.8 2.919921875e-05
+ 1.8 2.9199776785714283e-05 0.0 2.9210937499999998e-05 0.0 2.9211495535714284e-05 1.8
+ 2.9217075892857142e-05 1.8 2.9217633928571425e-05 0.0 2.922879464285714e-05 0.0 2.9229352678571427e-05 1.8
+ 2.9234933035714284e-05 1.8 2.923549107142857e-05 0.0 2.9246651785714282e-05 0.0 2.924720982142857e-05 1.8
+ 2.9252790178571426e-05 1.8 2.9253348214285713e-05 0.0 2.9264508928571428e-05 0.0 2.926506696428571e-05 1.8
+ 2.927064732142857e-05 1.8 2.9271205357142856e-05 0.0 2.928236607142857e-05 0.0 2.9282924107142854e-05 1.8
+ 2.928850446428571e-05 1.8 2.9289062499999998e-05 0.0 2.9300223214285713e-05 0.0 2.930078125e-05 1.8
+ 2.9306361607142853e-05 1.8 2.930691964285714e-05 0.0 2.9318080357142855e-05 0.0 2.9318638392857142e-05 1.8 2.932421875e-05
+ 1.8 2.9324776785714283e-05 0.0 2.933537946428571e-05 0.0 2.9335937499999997e-05 1.8
+ 2.9342633928571425e-05 1.8 2.934319196428571e-05 0.0 2.9353236607142856e-05 0.0 2.935379464285714e-05 1.8
+ 2.936049107142857e-05 1.8 2.9361049107142854e-05 0.0 2.937109375e-05 0.0 2.9371651785714282e-05 1.8
+ 2.9378348214285713e-05 1.8 2.9378906249999996e-05 0.0 2.938895089285714e-05 0.0 2.9389508928571428e-05 1.8
+ 2.9396205357142855e-05 1.8 2.9396763392857142e-05 0.0 2.9406808035714283e-05 0.0 2.940736607142857e-05 1.8
+ 2.9414062499999998e-05 1.8 2.9414620535714284e-05 0.0 2.9424665178571426e-05 0.0 2.9425223214285712e-05 1.8
+ 2.943191964285714e-05 1.8 2.9432477678571427e-05 0.0 2.9442522321428568e-05 0.0 2.9443080357142855e-05 1.8
+ 2.9449776785714282e-05 1.8 2.945033482142857e-05 0.0 2.9460379464285714e-05 0.0 2.9460937499999997e-05 1.8
+ 2.9467633928571428e-05 1.8 2.946819196428571e-05 0.0 2.9478236607142856e-05 0.0 2.947879464285714e-05 1.8
+ 2.948549107142857e-05 1.8 2.9486049107142854e-05 0.0 2.9496093749999998e-05 0.0 2.9496651785714285e-05 1.8
+ 2.9503348214285713e-05 1.8 2.950390625e-05 0.0 2.951395089285714e-05 0.0 2.9514508928571427e-05 1.8 2.9521205357142855e-05
+ 1.8 2.952176339285714e-05 0.0 2.9531808035714283e-05 0.0 2.953236607142857e-05 1.8
+ 2.9539062499999997e-05 1.8 2.9539620535714284e-05 0.0 2.9549665178571425e-05 0.0 2.9550223214285712e-05 1.8
+ 2.955691964285714e-05 1.8 2.9557477678571426e-05 0.0 2.956752232142857e-05 0.0 2.9568080357142854e-05 1.8
+ 2.9574776785714285e-05 1.8 2.957533482142857e-05 0.0 2.9585379464285713e-05 0.0 2.9585937499999997e-05 1.8
+ 2.9592633928571428e-05 1.8 2.959319196428571e-05 0.0 2.9603236607142856e-05 0.0 2.9603794642857142e-05 1.8
+ 2.961049107142857e-05 1.8 2.9611049107142857e-05 0.0 2.9621093749999998e-05 0.0 2.9621651785714285e-05 1.8
+ 2.9628348214285712e-05 1.8 2.962890625e-05 0.0 2.963895089285714e-05 0.0 2.9639508928571427e-05 1.8 2.9646205357142855e-05
+ 1.8 2.964676339285714e-05 0.0 2.9656808035714283e-05 0.0 2.965736607142857e-05 1.8
+ 2.9664062499999997e-05 1.8 2.9664620535714284e-05 0.0 2.9674665178571425e-05 0.0 2.967522321428571e-05 1.8
+ 2.9682477678571426e-05 1.8 2.9683035714285713e-05 0.0 2.9691964285714284e-05 0.0 2.969252232142857e-05 1.8
+ 2.9700334821428568e-05 1.8 2.9700892857142855e-05 0.0 2.9709821428571426e-05 0.0 2.9710379464285713e-05 1.8
+ 2.971819196428571e-05 1.8 2.9718749999999997e-05 0.0 2.972767857142857e-05 0.0 2.9728236607142855e-05 1.8
+ 2.9736049107142856e-05 1.8 2.973660714285714e-05 0.0 2.974553571428571e-05 0.0 2.9746093749999998e-05 1.8 2.975390625e-05
+ 1.8 2.9754464285714282e-05 0.0 2.9763392857142857e-05 0.0 2.976395089285714e-05 1.8
+ 2.977176339285714e-05 1.8 2.9772321428571428e-05 0.0 2.978125e-05 0.0 2.9781808035714282e-05 1.8 2.9789620535714283e-05
+ 1.8 2.979017857142857e-05 0.0 2.979910714285714e-05 0.0 2.9799665178571428e-05 1.8
+ 2.9807477678571426e-05 1.8 2.9808035714285712e-05 0.0 2.9816964285714283e-05 0.0 2.981752232142857e-05 1.8
+ 2.9825334821428568e-05 1.8 2.9825892857142855e-05 0.0 2.9834821428571426e-05 0.0 2.9835379464285713e-05 1.8
+ 2.9843191964285714e-05 1.8 2.9843749999999997e-05 0.0 2.9852678571428568e-05 0.0 2.9853236607142855e-05 1.8
+ 2.9861049107142856e-05 1.8 2.986160714285714e-05 0.0 2.9870535714285714e-05 0.0 2.9871093749999997e-05 1.8
+ 2.9878906249999998e-05 1.8 2.9879464285714285e-05 0.0 2.9888392857142856e-05 0.0 2.988895089285714e-05 1.8
+ 2.989676339285714e-05 1.8 2.9897321428571427e-05 0.0 2.990625e-05 0.0 2.9906808035714285e-05 1.8 2.9914620535714283e-05
+ 1.8 2.991517857142857e-05 0.0 2.992410714285714e-05 0.0 2.9924665178571428e-05 1.8
+ 2.9932477678571425e-05 1.8 2.9933035714285712e-05 0.0 2.9941964285714283e-05 0.0 2.994252232142857e-05 1.8
+ 2.995033482142857e-05 1.8 2.9950892857142854e-05 0.0 2.9959821428571425e-05 0.0 2.9960379464285712e-05 1.8
+ 2.9968191964285713e-05 1.8 2.9968749999999997e-05 0.0 2.9977678571428568e-05 0.0 2.9978236607142855e-05 1.8
+ 2.9986049107142856e-05 1.8 2.9986607142857142e-05 0.0 2.9995535714285713e-05 0.0 2.9996093749999997e-05 1.8
+ 3.0004464285714285e-05 1.8 3.0005022321428568e-05 0.0 3.001283482142857e-05 0.0 3.0013392857142856e-05 1.8
+ 3.0022321428571427e-05 1.8 3.0022879464285714e-05 0.0 3.003069196428571e-05 0.0 3.0031249999999998e-05 1.8
+ 3.004017857142857e-05 1.8 3.0040736607142856e-05 0.0 3.0048549107142854e-05 0.0 3.004910714285714e-05 1.8
+ 3.005803571428571e-05 1.8 3.005859375e-05 0.0 3.006640625e-05 0.0 3.0066964285714283e-05 1.8 3.0075892857142854e-05 1.8
+ 3.007645089285714e-05 0.0 3.0084263392857142e-05 0.0 3.0084821428571425e-05 1.8 3.0093749999999996e-05 1.8
+ 3.0094308035714283e-05 0.0 3.0102120535714284e-05 0.0 3.010267857142857e-05 1.8 3.0111607142857142e-05 1.8
+ 3.0112165178571425e-05 0.0 3.0119977678571426e-05 0.0 3.0120535714285713e-05 1.8 3.0129464285714284e-05 1.8
+ 3.0130022321428568e-05 0.0 3.013783482142857e-05 0.0 3.0138392857142855e-05 1.8 3.0147321428571427e-05 1.8
+ 3.0147879464285713e-05 0.0 3.015569196428571e-05 0.0 3.0156249999999998e-05 1.8 3.016517857142857e-05 1.8
+ 3.0165736607142856e-05 0.0 3.0173549107142853e-05 0.0 3.017410714285714e-05 1.8 3.018303571428571e-05 1.8
+ 3.0183593749999998e-05 0.0 3.019140625e-05 0.0 3.0191964285714282e-05 1.8 3.0200892857142854e-05 1.8 3.020145089285714e-05
+ 0.0 3.020926339285714e-05 0.0 3.0209821428571425e-05 1.8 3.021875e-05 1.8 3.0219308035714283e-05 0.0
+ 3.0227120535714284e-05 0.0 3.022767857142857e-05 1.8 3.023660714285714e-05 1.8 3.0237165178571425e-05 0.0
+ 3.0244977678571426e-05 0.0 3.0245535714285713e-05 1.8 3.0254464285714284e-05 1.8 3.025502232142857e-05 0.0
+ 3.026283482142857e-05 0.0 3.0263392857142855e-05 1.8 3.0272321428571426e-05 1.8 3.0272879464285713e-05 0.0
+ 3.028069196428571e-05 0.0 3.0281249999999997e-05 1.8 3.029017857142857e-05 1.8 3.0290736607142855e-05 0.0
+ 3.0298549107142856e-05 0.0 3.029910714285714e-05 1.8 3.030803571428571e-05 1.8 3.0308593749999998e-05 0.0 3.031640625e-05
+ 0.0 3.0316964285714282e-05 1.8 3.032645089285714e-05 1.8 3.0327008928571427e-05 0.0
+ 3.0333705357142854e-05 0.0 3.033426339285714e-05 1.8 3.0344308035714282e-05 1.8 3.034486607142857e-05 0.0
+ 3.0351562499999997e-05 0.0 3.0352120535714283e-05 1.8 3.0362165178571428e-05 1.8 3.036272321428571e-05 0.0
+ 3.0369419642857142e-05 0.0 3.0369977678571426e-05 1.8 3.038002232142857e-05 1.8 3.0380580357142854e-05 0.0
+ 3.0387276785714285e-05 0.0 3.0387834821428568e-05 1.8 3.0397879464285713e-05 1.8 3.03984375e-05 0.0 3.0405133928571427e-05
+ 0.0 3.0405691964285714e-05 1.8 3.0415736607142855e-05 1.8 3.0416294642857142e-05 0.0
+ 3.042299107142857e-05 0.0 3.0423549107142856e-05 1.8 3.0433593749999997e-05 1.8 3.0434151785714284e-05 0.0
+ 3.044084821428571e-05 0.0 3.044140625e-05 1.8 3.045145089285714e-05 1.8 3.0452008928571426e-05 0.0 3.0458705357142854e-05
+ 0.0 3.045926339285714e-05 1.8 3.0469308035714282e-05 1.8 3.046986607142857e-05 0.0
+ 3.0476562499999996e-05 0.0 3.0477120535714283e-05 1.8 3.0487165178571428e-05 1.8 3.048772321428571e-05 0.0
+ 3.0494419642857142e-05 0.0 3.0494977678571425e-05 1.8 3.050502232142857e-05 1.8 3.0505580357142853e-05 0.0
+ 3.0512276785714284e-05 0.0 3.0512834821428568e-05 1.8 3.052287946428571e-05 1.8 3.05234375e-05 0.0 3.0530133928571427e-05
+ 0.0 3.053069196428571e-05 1.8 3.054073660714286e-05 1.8 3.054129464285714e-05 0.0 3.054799107142857e-05
+ 0.0 3.054854910714285e-05 1.8 3.055859375e-05 1.8 3.0559151785714284e-05 0.0 3.056584821428571e-05 0.0
+ 3.0566406249999995e-05 1.8 3.057645089285714e-05 1.8 3.0577008928571426e-05 0.0 3.0583705357142854e-05 0.0
+ 3.0584263392857144e-05 1.8 3.0594308035714285e-05 1.8 3.059486607142857e-05 0.0 3.0601562499999996e-05 0.0
+ 3.0602120535714286e-05 1.8 3.061216517857143e-05 1.8 3.061272321428571e-05 0.0 3.061941964285714e-05 0.0
+ 3.061997767857143e-05 1.8 3.063002232142857e-05 1.8 3.063058035714285e-05 0.0 3.063727678571428e-05 0.0
+ 3.063783482142857e-05 1.8 3.064787946428571e-05 1.8 3.0648437499999995e-05 0.0 3.065513392857143e-05 0.0
+ 3.065569196428571e-05 1.8 3.0665736607142854e-05 1.8 3.066629464285714e-05 0.0 3.067243303571428e-05 0.0
+ 3.067299107142857e-05 1.8 3.068415178571429e-05 1.8 3.068470982142857e-05 0.0 3.0690290178571424e-05 0.0
+ 3.0690848214285714e-05 1.8 3.070200892857143e-05 1.8 3.070256696428571e-05 0.0 3.0708147321428566e-05 0.0
+ 3.070870535714286e-05 1.8 3.071986607142857e-05 1.8 3.0720424107142855e-05 0.0 3.072600446428571e-05 0.0 3.07265625e-05
+ 1.8 3.0737723214285714e-05 1.8 3.073828125e-05 0.0 3.074386160714286e-05 0.0 3.074441964285714e-05 1.8
+ 3.0755580357142856e-05 1.8 3.075613839285714e-05 0.0 3.076171875e-05 0.0 3.0762276785714284e-05 1.8 3.07734375e-05 1.8
+ 3.077399553571428e-05 0.0 3.077957589285714e-05 0.0 3.0780133928571426e-05 1.8 3.079129464285714e-05 1.8
+ 3.0791852678571424e-05 0.0 3.0797433035714285e-05 0.0 3.079799107142857e-05 1.8 3.080915178571428e-05 1.8
+ 3.0809709821428566e-05 0.0 3.081529017857143e-05 0.0 3.081584821428571e-05 1.8 3.0827008928571425e-05 1.8
+ 3.082756696428571e-05 0.0 3.083314732142857e-05 0.0 3.083370535714285e-05 1.8 3.084486607142857e-05 1.8
+ 3.084542410714286e-05 0.0 3.085100446428571e-05 0.0 3.0851562499999995e-05 1.8 3.086272321428571e-05 1.8 3.086328125e-05
+ 0.0 3.0868861607142854e-05 0.0 3.086941964285714e-05 1.8 3.088058035714285e-05 1.8
+ 3.088113839285714e-05 0.0 3.0886718749999996e-05 0.0 3.088727678571429e-05 1.8 3.0898437499999995e-05 1.8
+ 3.0898995535714285e-05 0.0 3.090457589285714e-05 0.0 3.090513392857143e-05 1.8 3.0916294642857144e-05 1.8
+ 3.091685267857143e-05 0.0 3.092243303571428e-05 0.0 3.092299107142857e-05 1.8 3.0934151785714286e-05 1.8
+ 3.093470982142857e-05 0.0 3.0940290178571423e-05 0.0 3.0940848214285714e-05 1.8 3.095200892857143e-05 1.8
+ 3.095256696428571e-05 0.0 3.095814732142857e-05 0.0 3.0958705357142856e-05 1.8 3.096986607142857e-05 1.8
+ 3.0970424107142854e-05 0.0 3.0976004464285715e-05 0.0 3.09765625e-05 1.8 3.098772321428571e-05 1.8 3.0988281249999996e-05
+ 0.0 3.099386160714286e-05 0.0 3.099441964285714e-05 1.8 3.1005580357142855e-05 1.8
+ 3.100613839285714e-05 0.0 3.101171875e-05 0.0 3.101227678571428e-05 1.8 3.10234375e-05 1.8 3.102399553571428e-05 0.0
+ 3.102957589285714e-05 0.0 3.1030133928571425e-05 1.8 3.104129464285714e-05 1.8 3.104185267857142e-05 0.0
+ 3.1047433035714284e-05 0.0 3.104799107142857e-05 1.8 3.105915178571428e-05 1.8 3.105970982142857e-05 0.0
+ 3.1065290178571426e-05 0.0 3.106584821428571e-05 1.8 3.1077008928571425e-05 1.8 3.1077566964285715e-05 0.0
+ 3.1082589285714285e-05 0.0 3.108314732142857e-05 1.8 3.109542410714286e-05 1.8 3.109598214285714e-05 0.0
+ 3.110044642857143e-05 0.0 3.110100446428571e-05 1.8 3.111328125e-05 1.8 3.111383928571428e-05 0.0 3.111830357142857e-05
+ 0.0 3.1118861607142853e-05 1.8 3.113113839285714e-05 1.8 3.1131696428571425e-05 0.0
+ 3.113616071428571e-05 0.0 3.1136718749999996e-05 1.8 3.1148995535714284e-05 1.8 3.114955357142857e-05 0.0
+ 3.1154017857142855e-05 0.0 3.115457589285714e-05 1.8 3.1166852678571426e-05 1.8 3.116741071428571e-05 0.0 3.1171875e-05
+ 0.0 3.117243303571428e-05 1.8 3.118470982142857e-05 1.8 3.118526785714285e-05 0.0 3.118973214285714e-05
+ 0.0 3.119029017857143e-05 1.8 3.120256696428571e-05 1.8 3.1203124999999994e-05 0.0
+ 3.120758928571428e-05 0.0 3.120814732142857e-05 1.8 3.122042410714285e-05 1.8 3.1220982142857144e-05 0.0
+ 3.1225446428571424e-05 0.0 3.1226004464285714e-05 1.8 3.1238281249999996e-05 1.8 3.1238839285714286e-05 0.0
+ 3.1243303571428566e-05 0.0 3.1243861607142856e-05 1.8 3.125613839285714e-05 1.8 3.125669642857143e-05 0.0
+ 3.126116071428571e-05 0.0 3.126171875e-05 1.8 3.127399553571428e-05 1.8 3.127455357142857e-05 0.0 3.127901785714286e-05
+ 0.0 3.127957589285714e-05 1.8 3.129185267857143e-05 1.8 3.129241071428571e-05 0.0 3.1296875e-05 0.0
+ 3.1297433035714283e-05 1.8 3.130970982142857e-05 1.8 3.1310267857142855e-05 0.0 3.131473214285714e-05 0.0
+ 3.1315290178571426e-05 1.8 3.1327566964285714e-05 1.8 3.1328125e-05 0.0 3.1332589285714285e-05 0.0 3.133314732142857e-05
+ 1.8 3.1345424107142856e-05 1.8 3.134598214285714e-05 0.0 3.135044642857143e-05 0.0
+ 3.135100446428571e-05 1.8 3.136328125e-05 1.8 3.136383928571428e-05 0.0 3.136830357142857e-05 0.0 3.136886160714285e-05
+ 1.8 3.138113839285714e-05 1.8 3.1381696428571424e-05 0.0 3.138616071428571e-05 0.0
+ 3.1386718749999995e-05 1.8 3.1398995535714283e-05 1.8 3.139955357142857e-05 0.0 3.1404017857142854e-05 0.0
+ 3.140457589285714e-05 1.8 3.1416852678571426e-05 1.8 3.141741071428571e-05 0.0 3.1421874999999996e-05 0.0
+ 3.1422433035714287e-05 1.8 3.143470982142857e-05 1.8 3.143526785714286e-05 0.0 3.143973214285714e-05 0.0
+ 3.144029017857143e-05 1.8 3.145256696428571e-05 1.8 3.1453125e-05 0.0 3.145758928571428e-05 0.0 3.145814732142857e-05 1.8
+ 3.147042410714285e-05 1.8 3.147098214285714e-05 0.0 3.147544642857142e-05 0.0 3.1476004464285713e-05 1.8
+ 3.1488281249999995e-05 1.8 3.1488839285714285e-05 0.0 3.149330357142857e-05 0.0 3.1493861607142856e-05 1.8
+ 3.150613839285714e-05 1.8 3.150669642857143e-05 0.0 3.1511160714285715e-05 0.0 3.151171875e-05 1.8 3.1523995535714286e-05
+ 1.8 3.152455357142857e-05 0.0 3.152901785714286e-05 0.0 3.152957589285714e-05 1.8 3.154185267857143e-05
+ 1.8 3.154241071428571e-05 0.0 3.1546875e-05 0.0 3.154743303571428e-05 1.8 3.155970982142857e-05 1.8
+ 3.1560267857142854e-05 0.0 3.156473214285714e-05 0.0 3.1565290178571425e-05 1.8 3.1577566964285713e-05 1.8 3.1578125e-05
+ 0.0 3.1582589285714284e-05 0.0 3.158314732142857e-05 1.8 3.1595424107142856e-05 1.8
+ 3.159598214285714e-05 0.0 3.1600446428571426e-05 0.0 3.160100446428571e-05 1.8 3.161328125e-05 1.8 3.161383928571428e-05
+ 0.0 3.161830357142857e-05 0.0 3.161886160714285e-05 1.8 3.163113839285714e-05 1.8
+ 3.1631696428571424e-05 0.0 3.163616071428571e-05 0.0 3.1636718749999994e-05 1.8 3.164899553571428e-05 1.8
+ 3.1649553571428566e-05 0.0 3.165401785714285e-05 0.0 3.1654575892857143e-05 1.8 3.1666852678571425e-05 1.8
+ 3.1667410714285715e-05 0.0 3.1671874999999996e-05 0.0 3.1672433035714286e-05 1.8 3.168470982142857e-05 1.8
+ 3.168526785714286e-05 0.0 3.168973214285714e-05 0.0 3.169029017857143e-05 1.8 3.170256696428571e-05 1.8 3.1703125e-05 0.0
+ 3.170758928571428e-05 0.0 3.170814732142857e-05 1.8 3.172042410714285e-05 1.8 3.172098214285714e-05 0.0
+ 3.172544642857143e-05 0.0 3.172600446428571e-05 1.8 3.173828125e-05 1.8 3.1738839285714284e-05 0.0 3.174330357142857e-05
+ 0.0 3.1743861607142855e-05 1.8 3.1756138392857143e-05 1.8 3.175669642857143e-05 0.0
+ 3.1761160714285714e-05 0.0 3.176171875e-05 1.8 3.1773995535714286e-05 1.8 3.177455357142857e-05 0.0 3.1779017857142856e-05
+ 0.0 3.177957589285714e-05 1.8 3.179185267857143e-05 1.8 3.179241071428571e-05 0.0 3.1796875e-05 0.0
+ 3.179743303571428e-05 1.8 3.180970982142857e-05 1.8 3.1810267857142854e-05 0.0 3.181473214285714e-05 0.0
+ 3.1815290178571424e-05 1.8 3.182756696428571e-05 1.8 3.1828124999999996e-05 0.0 3.183258928571428e-05 0.0
+ 3.183314732142857e-05 1.8 3.1845424107142855e-05 1.8 3.184598214285714e-05 0.0 3.1850446428571426e-05 0.0
+ 3.185100446428571e-05 1.8 3.186328125e-05 1.8 3.186383928571428e-05 0.0 3.186830357142857e-05 0.0 3.186886160714286e-05
+ 1.8 3.188113839285714e-05 1.8 3.188169642857142e-05 0.0 3.188616071428571e-05 0.0 3.188671875e-05 1.8
+ 3.189899553571428e-05 1.8 3.189955357142857e-05 0.0 3.190401785714285e-05 0.0 3.190457589285714e-05 1.8
+ 3.1916852678571424e-05 1.8 3.1917410714285714e-05 0.0 3.1921874999999995e-05 0.0 3.1922433035714285e-05 1.8
+ 3.193470982142857e-05 1.8 3.193526785714286e-05 0.0 3.193973214285714e-05 0.0 3.194029017857143e-05 1.8
+ 3.195256696428571e-05 1.8 3.1953125e-05 0.0 3.1957589285714286e-05 0.0 3.195814732142857e-05 1.8 3.197042410714286e-05
+ 1.8 3.197098214285714e-05 0.0 3.197544642857143e-05 0.0 3.197600446428571e-05 1.8 3.198828125e-05 1.8
+ 3.1988839285714284e-05 0.0 3.199330357142857e-05 0.0 3.1993861607142854e-05 1.8 )
Vmeas3 vinp_I_pwm vinp_I 0
.save i(vmeas3)
Vmeasn4 vinn_I_pwm vinn_I 0
.save i(vmeasn4)
E1 Vcm vinn_Q_sine net4 GND 0.5
E7 vinp_Q_sine Vcm net4 GND 0.5
E8 net4 GND vind_Q GND 1
vcosine vind_I GND sin(0 {VDD/2} {fsig} 0 0 90)
E9 net6 GND vinp_Q_pwm GND -1
Vofs_I net5 GND {VDD}
E10 vinn_Q_pwm net5 net6 GND 1
vpwm_sine_50 vinp_Q_pwm GND dc 0 pwl(0.0 1.8 4.464285714285714e-09 1.8 5.022321428571428e-09 0.0
+ 1.2834821428571427e-08 0.0 1.3392857142857143e-08 1.8 2.232142857142857e-08 1.8 2.2879464285714283e-08 0.0
+ 3.069196428571428e-08 0.0 3.125e-08 1.8 4.0178571428571425e-08 1.8 4.073660714285714e-08 0.0 4.854910714285714e-08 0.0
+ 4.910714285714285e-08 1.8 5.8035714285714284e-08 1.8 5.8593749999999995e-08 0.0 6.640625e-08 0.0 6.696428571428571e-08
+ 1.8 7.589285714285714e-08 1.8 7.645089285714285e-08 0.0 8.426339285714285e-08 0.0 8.482142857142856e-08
+ 1.8 9.374999999999999e-08 1.8 9.430803571428571e-08 0.0 1.021205357142857e-07 0.0
+ 1.0267857142857142e-07 1.8 1.1160714285714285e-07 1.8 1.1216517857142857e-07 0.0 1.1997767857142856e-07 0.0
+ 1.2053571428571428e-07 1.8 1.294642857142857e-07 1.8 1.3002232142857143e-07 0.0 1.378348214285714e-07 0.0
+ 1.3839285714285713e-07 1.8 1.4732142857142856e-07 1.8 1.4787946428571428e-07 0.0 1.5569196428571426e-07 0.0
+ 1.5624999999999999e-07 1.8 1.651785714285714e-07 1.8 1.6573660714285714e-07 0.0 1.7354910714285714e-07 0.0
+ 1.7410714285714284e-07 1.8 1.8303571428571427e-07 1.8 1.8359375e-07 0.0 1.9140625e-07 0.0 1.919642857142857e-07 1.8
+ 2.0089285714285712e-07 1.8 2.0145089285714284e-07 0.0 2.0926339285714285e-07 0.0 2.0982142857142854e-07 1.8 2.1875e-07 1.8
+ 2.193080357142857e-07 0.0 2.271205357142857e-07 0.0 2.2767857142857142e-07 1.8 2.3660714285714285e-07 1.8
+ 2.3716517857142855e-07 0.0 2.4497767857142855e-07 0.0 2.4553571428571425e-07 1.8 2.544642857142857e-07 1.8
+ 2.550223214285714e-07 0.0 2.628348214285714e-07 0.0 2.633928571428571e-07 1.8 2.7232142857142853e-07 1.8
+ 2.728794642857143e-07 0.0 2.8069196428571426e-07 0.0 2.8124999999999995e-07 1.8 2.9017857142857143e-07 1.8
+ 2.9073660714285713e-07 0.0 2.985491071428571e-07 0.0 2.9910714285714286e-07 1.8 3.080357142857143e-07 1.8 3.0859375e-07
+ 0.0 3.1640624999999996e-07 0.0 3.169642857142857e-07 1.8 3.2645089285714284e-07 1.8
+ 3.2700892857142853e-07 0.0 3.337053571428571e-07 0.0 3.342633928571428e-07 1.8 3.443080357142857e-07 1.8
+ 3.448660714285714e-07 0.0 3.5156249999999997e-07 0.0 3.5212053571428567e-07 1.8 3.6216517857142854e-07 1.8
+ 3.6272321428571424e-07 0.0 3.694196428571428e-07 0.0 3.699776785714285e-07 1.8 3.800223214285714e-07 1.8
+ 3.805803571428571e-07 0.0 3.872767857142857e-07 0.0 3.878348214285714e-07 1.8 3.9787946428571425e-07 1.8 3.984375e-07 0.0
+ 4.0513392857142853e-07 0.0 4.056919642857143e-07 1.8 4.157366071428571e-07 1.8 4.1629464285714285e-07 0.0
+ 4.229910714285714e-07 0.0 4.2354910714285713e-07 1.8 4.3359374999999995e-07 1.8 4.341517857142857e-07 0.0
+ 4.4084821428571423e-07 0.0 4.4140625e-07 1.8 4.514508928571428e-07 1.8 4.5200892857142855e-07 0.0 4.587053571428571e-07
+ 0.0 4.5926339285714284e-07 1.8 4.6930803571428566e-07 1.8 4.698660714285714e-07 0.0 4.765625e-07 0.0
+ 4.771205357142856e-07 1.8 4.871651785714285e-07 1.8 4.877232142857142e-07 0.0 4.944196428571428e-07 0.0
+ 4.949776785714285e-07 1.8 5.050223214285714e-07 1.8 5.055803571428571e-07 0.0 5.122767857142856e-07 0.0
+ 5.128348214285713e-07 1.8 5.228794642857142e-07 1.8 5.234374999999999e-07 0.0 5.301339285714285e-07 0.0
+ 5.306919642857143e-07 1.8 5.407366071428571e-07 1.8 5.412946428571429e-07 0.0 5.479910714285713e-07 0.0
+ 5.485491071428572e-07 1.8 5.585937499999999e-07 1.8 5.591517857142857e-07 0.0 5.658482142857142e-07 0.0 5.6640625e-07 1.8
+ 5.764508928571428e-07 1.8 5.770089285714286e-07 0.0 5.83705357142857e-07 0.0 5.842633928571429e-07 1.8
+ 5.943080357142856e-07 1.8 5.948660714285714e-07 0.0 6.015624999999999e-07 0.0 6.021205357142857e-07 1.8
+ 6.121651785714285e-07 1.8 6.127232142857143e-07 0.0 6.194196428571429e-07 0.0 6.199776785714286e-07 1.8
+ 6.300223214285714e-07 1.8 6.305803571428571e-07 0.0 6.372767857142857e-07 0.0 6.378348214285714e-07 1.8
+ 6.478794642857143e-07 1.8 6.484375e-07 0.0 6.551339285714286e-07 0.0 6.556919642857143e-07 1.8 6.657366071428571e-07 1.8
+ 6.662946428571428e-07 0.0 6.724330357142856e-07 0.0 6.729910714285714e-07 1.8 6.841517857142857e-07 1.8
+ 6.847098214285714e-07 0.0 6.902901785714285e-07 0.0 6.908482142857143e-07 1.8 7.020089285714285e-07 1.8
+ 7.025669642857142e-07 0.0 7.081473214285714e-07 0.0 7.087053571428571e-07 1.8 7.198660714285714e-07 1.8
+ 7.204241071428571e-07 0.0 7.260044642857143e-07 0.0 7.265625e-07 1.8 7.377232142857142e-07 1.8 7.382812499999999e-07 0.0
+ 7.438616071428571e-07 0.0 7.444196428571428e-07 1.8 7.555803571428571e-07 1.8 7.561383928571428e-07 0.0 7.6171875e-07 0.0
+ 7.622767857142857e-07 1.8 7.734375e-07 1.8 7.739955357142857e-07 0.0 7.795758928571428e-07 0.0 7.801339285714285e-07 1.8
+ 7.912946428571428e-07 1.8 7.918526785714285e-07 0.0 7.974330357142857e-07 0.0 7.979910714285714e-07 1.8
+ 8.091517857142857e-07 1.8 8.097098214285714e-07 0.0 8.152901785714285e-07 0.0 8.158482142857142e-07 1.8
+ 8.270089285714285e-07 1.8 8.275669642857142e-07 0.0 8.331473214285714e-07 0.0 8.337053571428571e-07 1.8
+ 8.448660714285714e-07 1.8 8.454241071428571e-07 0.0 8.510044642857142e-07 0.0 8.515624999999999e-07 1.8
+ 8.627232142857142e-07 1.8 8.632812499999999e-07 0.0 8.688616071428571e-07 0.0 8.694196428571428e-07 1.8
+ 8.805803571428571e-07 1.8 8.811383928571428e-07 0.0 8.8671875e-07 0.0 8.872767857142857e-07 1.8 8.984374999999999e-07 1.8
+ 8.989955357142856e-07 0.0 9.045758928571428e-07 0.0 9.051339285714285e-07 1.8 9.162946428571428e-07 1.8
+ 9.168526785714285e-07 0.0 9.224330357142857e-07 0.0 9.229910714285714e-07 1.8 9.341517857142856e-07 1.8
+ 9.347098214285713e-07 0.0 9.402901785714285e-07 0.0 9.408482142857142e-07 1.8 9.520089285714285e-07 1.8
+ 9.525669642857142e-07 0.0 9.581473214285714e-07 0.0 9.58705357142857e-07 1.8 9.698660714285714e-07 1.8
+ 9.704241071428571e-07 0.0 9.760044642857141e-07 0.0 9.765625e-07 1.8 9.877232142857142e-07 1.8 9.882812499999999e-07 0.0
+ 9.93861607142857e-07 0.0 9.944196428571428e-07 1.8 1.0055803571428571e-06 1.8 1.0061383928571428e-06 0.0 1.01171875e-06
+ 0.0 1.0122767857142857e-06 1.8 1.0234374999999999e-06 1.8 1.0239955357142856e-06 0.0
+ 1.0295758928571428e-06 0.0 1.0301339285714285e-06 1.8 1.0412946428571428e-06 1.8 1.0418526785714285e-06 0.0
+ 1.0474330357142857e-06 0.0 1.0479910714285714e-06 1.8 1.0591517857142856e-06 1.8 1.0597098214285713e-06 0.0
+ 1.0652901785714285e-06 0.0 1.0658482142857142e-06 1.8 1.0770089285714286e-06 1.8 1.0775669642857143e-06 0.0
+ 1.0825892857142857e-06 0.0 1.0831473214285714e-06 1.8 1.095424107142857e-06 1.8 1.0959821428571427e-06 0.0
+ 1.1004464285714285e-06 0.0 1.1010044642857142e-06 1.8 1.11328125e-06 1.8 1.1138392857142857e-06 0.0 1.1183035714285714e-06
+ 0.0 1.1188616071428571e-06 1.8 1.1311383928571427e-06 1.8 1.1316964285714284e-06 0.0
+ 1.1361607142857142e-06 0.0 1.1367187499999999e-06 1.8 1.1489955357142857e-06 1.8 1.1495535714285714e-06 0.0
+ 1.1540178571428572e-06 0.0 1.1545758928571428e-06 1.8 1.1668526785714284e-06 1.8 1.167410714285714e-06 0.0 1.171875e-06
+ 0.0 1.1724330357142856e-06 1.8 1.1847098214285714e-06 1.8 1.185267857142857e-06 0.0
+ 1.1897321428571429e-06 0.0 1.1902901785714286e-06 1.8 1.2025669642857141e-06 1.8 1.2031249999999998e-06 0.0
+ 1.2075892857142856e-06 0.0 1.2081473214285713e-06 1.8 1.220424107142857e-06 1.8 1.2209821428571428e-06 0.0
+ 1.2254464285714286e-06 0.0 1.2260044642857143e-06 1.8 1.2382812499999998e-06 1.8 1.2388392857142857e-06 0.0
+ 1.2433035714285713e-06 0.0 1.243861607142857e-06 1.8 1.2561383928571428e-06 1.8 1.2566964285714285e-06 0.0
+ 1.2611607142857143e-06 0.0 1.26171875e-06 1.8 1.2739955357142855e-06 1.8 1.2745535714285714e-06 0.0 1.279017857142857e-06
+ 0.0 1.2795758928571427e-06 1.8 1.2918526785714285e-06 1.8 1.2924107142857142e-06 0.0 1.296875e-06 0.0
+ 1.2974330357142857e-06 1.8 1.3097098214285714e-06 1.8 1.3102678571428571e-06 0.0 1.3147321428571427e-06 0.0
+ 1.3152901785714284e-06 1.8 1.3275669642857142e-06 1.8 1.3281249999999999e-06 0.0 1.3325892857142857e-06 0.0
+ 1.3331473214285714e-06 1.8 1.3454241071428571e-06 1.8 1.3459821428571428e-06 0.0 1.3504464285714284e-06 0.0
+ 1.3510044642857141e-06 1.8 1.3632812499999999e-06 1.8 1.3638392857142856e-06 0.0 1.3683035714285714e-06 0.0
+ 1.368861607142857e-06 1.8 1.3811383928571428e-06 1.8 1.3816964285714285e-06 0.0 1.3861607142857141e-06 0.0
+ 1.3867187499999998e-06 1.8 1.3989955357142856e-06 1.8 1.3995535714285713e-06 0.0 1.404017857142857e-06 0.0
+ 1.4045758928571428e-06 1.8 1.4168526785714286e-06 1.8 1.4174107142857143e-06 0.0 1.4218749999999998e-06 0.0
+ 1.4224330357142855e-06 1.8 1.4347098214285713e-06 1.8 1.435267857142857e-06 0.0 1.4397321428571428e-06 0.0
+ 1.4402901785714285e-06 1.8 1.4525669642857143e-06 1.8 1.453125e-06 0.0 1.4575892857142855e-06 0.0 1.4581473214285712e-06
+ 1.8 1.470424107142857e-06 1.8 1.4709821428571427e-06 0.0 1.4754464285714285e-06 0.0
+ 1.4760044642857142e-06 1.8 1.48828125e-06 1.8 1.4888392857142857e-06 0.0 1.4933035714285712e-06 0.0 1.493861607142857e-06
+ 1.8 1.5061383928571427e-06 1.8 1.5066964285714284e-06 0.0 1.5111607142857142e-06 0.0 1.51171875e-06 1.8
+ 1.5239955357142857e-06 1.8 1.5245535714285714e-06 0.0 1.529017857142857e-06 0.0 1.5295758928571426e-06 1.8
+ 1.5418526785714284e-06 1.8 1.5424107142857141e-06 0.0 1.546875e-06 0.0 1.5474330357142856e-06 1.8 1.5597098214285714e-06
+ 1.8 1.560267857142857e-06 0.0 1.5647321428571427e-06 0.0 1.5652901785714286e-06 1.8
+ 1.5775669642857141e-06 1.8 1.5781249999999998e-06 0.0 1.5825892857142856e-06 0.0 1.5831473214285713e-06 1.8
+ 1.595424107142857e-06 1.8 1.5959821428571428e-06 0.0 1.6004464285714284e-06 0.0 1.6010044642857143e-06 1.8
+ 1.6132812499999998e-06 1.8 1.6138392857142855e-06 0.0 1.6183035714285713e-06 0.0 1.618861607142857e-06 1.8
+ 1.6311383928571428e-06 1.8 1.6316964285714285e-06 0.0 1.636160714285714e-06 0.0 1.63671875e-06 1.8 1.6489955357142855e-06
+ 1.8 1.6495535714285712e-06 0.0 1.654017857142857e-06 0.0 1.6545758928571427e-06 1.8
+ 1.6668526785714285e-06 1.8 1.6674107142857142e-06 0.0 1.671875e-06 0.0 1.6724330357142857e-06 1.8 1.6847098214285712e-06
+ 1.8 1.685267857142857e-06 0.0 1.6897321428571427e-06 0.0 1.6902901785714284e-06 1.8
+ 1.7025669642857142e-06 1.8 1.7031249999999999e-06 0.0 1.7075892857142857e-06 0.0 1.7081473214285714e-06 1.8
+ 1.720424107142857e-06 1.8 1.7209821428571426e-06 0.0 1.7254464285714284e-06 0.0 1.7260044642857141e-06 1.8 1.73828125e-06
+ 1.8 1.7388392857142856e-06 0.0 1.7433035714285714e-06 0.0 1.743861607142857e-06 1.8
+ 1.7561383928571426e-06 1.8 1.7566964285714283e-06 0.0 1.7611607142857141e-06 0.0 1.7617187499999998e-06 1.8
+ 1.7739955357142856e-06 1.8 1.7745535714285713e-06 0.0 1.779017857142857e-06 0.0 1.7795758928571428e-06 1.8
+ 1.7918526785714284e-06 1.8 1.7924107142857143e-06 0.0 1.7968749999999998e-06 0.0 1.7974330357142855e-06 1.8
+ 1.8097098214285713e-06 1.8 1.810267857142857e-06 0.0 1.8147321428571428e-06 0.0 1.8152901785714285e-06 1.8
+ 1.827566964285714e-06 1.8 1.828125e-06 0.0 1.8325892857142855e-06 0.0 1.8331473214285712e-06 1.8 1.845424107142857e-06
+ 1.8 1.8459821428571427e-06 0.0 1.8504464285714285e-06 0.0 1.8510044642857142e-06 1.8
+ 1.8632812499999998e-06 1.8 1.8638392857142857e-06 0.0 1.8683035714285713e-06 0.0 1.868861607142857e-06 1.8
+ 1.8811383928571427e-06 1.8 1.8816964285714284e-06 0.0 1.8861607142857142e-06 0.0 1.88671875e-06 1.8 1.8989955357142857e-06
+ 1.8 1.8995535714285714e-06 0.0 1.904017857142857e-06 0.0 1.9045758928571427e-06 1.8
+ 1.9168526785714286e-06 1.8 1.917410714285714e-06 0.0 1.9218749999999997e-06 0.0 1.9224330357142856e-06 1.8
+ 1.9347098214285714e-06 1.8 1.935267857142857e-06 0.0 1.939732142857143e-06 0.0 1.9402901785714284e-06 1.8
+ 1.952566964285714e-06 1.8 1.953125e-06 0.0 1.9575892857142856e-06 0.0 1.958147321428571e-06 1.8 1.970424107142857e-06 1.8
+ 1.9709821428571428e-06 0.0 1.9754464285714284e-06 0.0 1.9760044642857143e-06 1.8 1.98828125e-06 1.8 1.9888392857142855e-06
+ 0.0 1.993303571428571e-06 0.0 1.993861607142857e-06 1.8 2.006138392857143e-06 1.8
+ 2.0066964285714283e-06 0.0 2.0111607142857143e-06 0.0 2.0117187499999998e-06 1.8 2.0239955357142855e-06 1.8
+ 2.0245535714285715e-06 0.0 2.029017857142857e-06 0.0 2.0295758928571425e-06 1.8 2.0418526785714283e-06 1.8
+ 2.042410714285714e-06 0.0 2.0468749999999998e-06 0.0 2.0474330357142857e-06 1.8 2.0597098214285715e-06 1.8
+ 2.060267857142857e-06 0.0 2.0647321428571425e-06 0.0 2.0652901785714284e-06 1.8 2.077566964285714e-06 1.8
+ 2.0781249999999997e-06 0.0 2.0825892857142857e-06 0.0 2.083147321428571e-06 1.8 2.095424107142857e-06 1.8
+ 2.095982142857143e-06 0.0 2.1004464285714284e-06 0.0 2.101004464285714e-06 1.8 2.1132812499999997e-06 1.8
+ 2.1138392857142856e-06 0.0 2.118303571428571e-06 0.0 2.118861607142857e-06 1.8 2.131138392857143e-06 1.8
+ 2.1316964285714284e-06 0.0 2.136160714285714e-06 0.0 2.13671875e-06 1.8 2.1489955357142856e-06 1.8 2.149553571428571e-06
+ 0.0 2.154017857142857e-06 0.0 2.1545758928571426e-06 1.8 2.1668526785714284e-06 1.8
+ 2.1674107142857143e-06 0.0 2.171875e-06 0.0 2.1724330357142858e-06 1.8 2.184709821428571e-06 1.8 2.185267857142857e-06 0.0
+ 2.1897321428571426e-06 0.0 2.1902901785714285e-06 1.8 2.2025669642857143e-06 1.8 2.2031249999999998e-06 0.0
+ 2.2075892857142853e-06 0.0 2.2081473214285713e-06 1.8 2.220424107142857e-06 1.8 2.2209821428571425e-06 0.0
+ 2.2254464285714285e-06 0.0 2.226004464285714e-06 1.8 2.2382812499999998e-06 1.8 2.2388392857142857e-06 0.0
+ 2.2433035714285713e-06 0.0 2.243861607142857e-06 1.8 2.2561383928571425e-06 1.8 2.2566964285714284e-06 0.0
+ 2.261160714285714e-06 0.0 2.26171875e-06 1.8 2.2739955357142857e-06 1.8 2.274553571428571e-06 0.0 2.279017857142857e-06
+ 0.0 2.2795758928571427e-06 1.8 2.2918526785714284e-06 1.8 2.292410714285714e-06 0.0 2.296875e-06 0.0
+ 2.2974330357142854e-06 1.8 2.309709821428571e-06 1.8 2.310267857142857e-06 0.0 2.3147321428571427e-06 0.0
+ 2.3152901785714286e-06 1.8 2.327566964285714e-06 1.8 2.328125e-06 0.0 2.3325892857142854e-06 0.0 2.3331473214285713e-06
+ 1.8 2.345424107142857e-06 1.8 2.3459821428571426e-06 0.0 2.3504464285714286e-06 0.0
+ 2.351004464285714e-06 1.8 2.36328125e-06 1.8 2.3638392857142858e-06 0.0 2.3683035714285713e-06 0.0 2.368861607142857e-06
+ 1.8 2.3811383928571426e-06 1.8 2.3816964285714285e-06 0.0 2.386160714285714e-06 0.0 2.38671875e-06 1.8
+ 2.3989955357142853e-06 1.8 2.3995535714285712e-06 0.0 2.404017857142857e-06 0.0 2.4045758928571427e-06 1.8
+ 2.4168526785714285e-06 1.8 2.417410714285714e-06 0.0 2.421875e-06 0.0 2.4224330357142855e-06 1.8 2.4347098214285713e-06
+ 1.8 2.435267857142857e-06 0.0 2.4397321428571427e-06 0.0 2.4402901785714282e-06 1.8
+ 2.452566964285714e-06 1.8 2.453125e-06 0.0 2.4575892857142855e-06 0.0 2.4581473214285714e-06 1.8 2.470424107142857e-06
+ 1.8 2.4709821428571427e-06 0.0 2.4754464285714282e-06 0.0 2.476004464285714e-06 1.8 2.48828125e-06 1.8
+ 2.4888392857142854e-06 0.0 2.4933035714285714e-06 0.0 2.493861607142857e-06 1.8 2.5061383928571427e-06 1.8
+ 2.5066964285714286e-06 0.0 2.511160714285714e-06 0.0 2.5117187499999996e-06 1.8 2.5239955357142854e-06 1.8
+ 2.5245535714285713e-06 0.0 2.529017857142857e-06 0.0 2.529575892857143e-06 1.8 2.5418526785714286e-06 1.8
+ 2.542410714285714e-06 0.0 2.5468749999999996e-06 0.0 2.5474330357142856e-06 1.8 2.5597098214285713e-06 1.8
+ 2.560267857142857e-06 0.0 2.564732142857143e-06 0.0 2.5652901785714283e-06 1.8 2.577566964285714e-06 1.8 2.578125e-06 0.0
+ 2.5825892857142856e-06 0.0 2.583147321428571e-06 1.8 2.595424107142857e-06 1.8 2.5959821428571427e-06 0.0
+ 2.6004464285714283e-06 0.0 2.6010044642857142e-06 1.8 2.61328125e-06 1.8 2.6138392857142855e-06 0.0 2.618303571428571e-06
+ 0.0 2.618861607142857e-06 1.8 2.6311383928571427e-06 1.8 2.6316964285714282e-06 0.0
+ 2.6361607142857142e-06 0.0 2.6367187499999997e-06 1.8 2.6489955357142855e-06 1.8 2.6495535714285714e-06 0.0
+ 2.654017857142857e-06 0.0 2.6545758928571425e-06 1.8 2.6668526785714282e-06 1.8 2.667410714285714e-06 0.0
+ 2.6718749999999997e-06 0.0 2.6724330357142856e-06 1.8 2.6847098214285714e-06 1.8 2.685267857142857e-06 0.0
+ 2.6897321428571425e-06 0.0 2.6902901785714284e-06 1.8 2.702566964285714e-06 1.8 2.7031249999999996e-06 0.0
+ 2.7075892857142856e-06 0.0 2.708147321428571e-06 1.8 2.720424107142857e-06 1.8 2.720982142857143e-06 0.0
+ 2.7254464285714284e-06 0.0 2.7260044642857143e-06 1.8 2.7382812499999996e-06 1.8 2.7388392857142856e-06 0.0
+ 2.743303571428571e-06 0.0 2.743861607142857e-06 1.8 2.756138392857143e-06 1.8 2.7566964285714283e-06 0.0
+ 2.761160714285714e-06 0.0 2.76171875e-06 1.8 2.7739955357142856e-06 1.8 2.774553571428571e-06 0.0 2.779017857142857e-06
+ 0.0 2.7795758928571425e-06 1.8 2.7918526785714283e-06 1.8 2.7924107142857142e-06 0.0 2.796875e-06 0.0
+ 2.7974330357142857e-06 1.8 2.809709821428571e-06 1.8 2.810267857142857e-06 0.0 2.8147321428571425e-06 0.0
+ 2.8152901785714285e-06 1.8 2.8275669642857142e-06 1.8 2.8281249999999997e-06 0.0 2.8325892857142857e-06 0.0
+ 2.833147321428571e-06 1.8 2.845424107142857e-06 1.8 2.8459821428571425e-06 0.0 2.8504464285714285e-06 0.0
+ 2.851004464285714e-06 1.8 2.8632812499999997e-06 1.8 2.8638392857142856e-06 0.0 2.868303571428571e-06 0.0
+ 2.868861607142857e-06 1.8 2.8811383928571425e-06 1.8 2.8816964285714284e-06 0.0 2.886160714285714e-06 0.0 2.88671875e-06
+ 1.8 2.8989955357142856e-06 1.8 2.899553571428571e-06 0.0 2.904017857142857e-06 0.0
+ 2.9045758928571426e-06 1.8 2.9168526785714284e-06 1.8 2.917410714285714e-06 0.0 2.9224330357142854e-06 0.0
+ 2.9229910714285713e-06 1.8 2.9341517857142856e-06 1.8 2.934709821428571e-06 0.0 2.9402901785714285e-06 0.0
+ 2.940848214285714e-06 1.8 2.9520089285714284e-06 1.8 2.952566964285714e-06 0.0 2.9581473214285713e-06 0.0
+ 2.9587053571428568e-06 1.8 2.969866071428571e-06 1.8 2.970424107142857e-06 0.0 2.976004464285714e-06 0.0 2.9765625e-06 1.8
+ 2.987723214285714e-06 1.8 2.98828125e-06 0.0 2.9938616071428568e-06 0.0 2.9944196428571427e-06 1.8 3.005580357142857e-06
+ 1.8 3.0061383928571425e-06 0.0 3.01171875e-06 0.0 3.0122767857142854e-06 1.8 3.0234375e-06 1.8
+ 3.0239955357142857e-06 0.0 3.0295758928571427e-06 0.0 3.030133928571428e-06 1.8 3.0412946428571425e-06 1.8
+ 3.0418526785714285e-06 0.0 3.0474330357142854e-06 0.0 3.0479910714285713e-06 1.8 3.0591517857142853e-06 1.8
+ 3.059709821428571e-06 0.0 3.065290178571428e-06 0.0 3.065848214285714e-06 1.8 3.0770089285714285e-06 1.8
+ 3.077566964285714e-06 0.0 3.0831473214285713e-06 0.0 3.083705357142857e-06 1.8 3.094866071428571e-06 1.8
+ 3.095424107142857e-06 0.0 3.101004464285714e-06 0.0 3.1015624999999996e-06 1.8 3.112723214285714e-06 1.8 3.11328125e-06
+ 0.0 3.118861607142857e-06 0.0 3.1194196428571428e-06 1.8 3.130580357142857e-06 1.8
+ 3.1311383928571426e-06 0.0 3.1367187499999996e-06 0.0 3.1372767857142855e-06 1.8 3.1484375e-06 1.8 3.1489955357142854e-06
+ 0.0 3.1545758928571428e-06 0.0 3.1551339285714282e-06 1.8 3.1662946428571426e-06 1.8
+ 3.1668526785714285e-06 0.0 3.1724330357142855e-06 0.0 3.172991071428571e-06 1.8 3.1841517857142854e-06 1.8
+ 3.1847098214285713e-06 0.0 3.1902901785714283e-06 0.0 3.190848214285714e-06 1.8 3.2020089285714285e-06 1.8
+ 3.202566964285714e-06 0.0 3.208147321428571e-06 0.0 3.208705357142857e-06 1.8 3.2198660714285713e-06 1.8
+ 3.2204241071428568e-06 0.0 3.226004464285714e-06 0.0 3.2265624999999997e-06 1.8 3.237723214285714e-06 1.8 3.23828125e-06
+ 0.0 3.243861607142857e-06 0.0 3.244419642857143e-06 1.8 3.2555803571428568e-06 1.8
+ 3.2561383928571427e-06 0.0 3.2617187499999997e-06 0.0 3.2622767857142856e-06 1.8 3.2734375e-06 1.8 3.2739955357142854e-06
+ 0.0 3.279575892857143e-06 0.0 3.2801339285714283e-06 1.8 3.2912946428571427e-06 1.8
+ 3.291852678571428e-06 0.0 3.2974330357142856e-06 0.0 3.297991071428571e-06 1.8 3.3091517857142854e-06 1.8
+ 3.3097098214285713e-06 0.0 3.3152901785714283e-06 0.0 3.3158482142857142e-06 1.8 3.327008928571428e-06 1.8
+ 3.327566964285714e-06 0.0 3.333705357142857e-06 0.0 3.3342633928571425e-06 1.8 3.3443080357142854e-06 1.8
+ 3.3448660714285714e-06 0.0 3.3515624999999997e-06 0.0 3.3521205357142856e-06 1.8 3.362165178571428e-06 1.8
+ 3.362723214285714e-06 0.0 3.3694196428571425e-06 0.0 3.3699776785714284e-06 1.8 3.3800223214285714e-06 1.8
+ 3.380580357142857e-06 0.0 3.3872767857142856e-06 0.0 3.387834821428571e-06 1.8 3.397879464285714e-06 1.8
+ 3.3984374999999996e-06 0.0 3.4051339285714284e-06 0.0 3.405691964285714e-06 1.8 3.415736607142857e-06 1.8
+ 3.4162946428571428e-06 0.0 3.422991071428571e-06 0.0 3.423549107142857e-06 1.8 3.4335937499999996e-06 1.8
+ 3.4341517857142855e-06 0.0 3.440848214285714e-06 0.0 3.44140625e-06 1.8 3.4514508928571428e-06 1.8 3.4520089285714283e-06
+ 0.0 3.458705357142857e-06 0.0 3.4592633928571425e-06 1.8 3.4693080357142855e-06 1.8
+ 3.469866071428571e-06 0.0 3.4765625e-06 0.0 3.4771205357142853e-06 1.8 3.4871651785714283e-06 1.8 3.487723214285714e-06
+ 0.0 3.4944196428571425e-06 0.0 3.4949776785714285e-06 1.8 3.505022321428571e-06 1.8
+ 3.505580357142857e-06 0.0 3.5122767857142853e-06 0.0 3.512834821428571e-06 1.8 3.522879464285714e-06 1.8
+ 3.5234374999999997e-06 0.0 3.5301339285714285e-06 0.0 3.530691964285714e-06 1.8 3.540736607142857e-06 1.8
+ 3.5412946428571424e-06 0.0 3.547991071428571e-06 0.0 3.5485491071428567e-06 1.8 3.5585937499999997e-06 1.8
+ 3.5591517857142856e-06 0.0 3.565848214285714e-06 0.0 3.56640625e-06 1.8 3.5764508928571424e-06 1.8 3.5770089285714283e-06
+ 0.0 3.5837053571428567e-06 0.0 3.5842633928571426e-06 1.8 3.5943080357142856e-06 1.8
+ 3.594866071428571e-06 0.0 3.6015625e-06 0.0 3.6021205357142854e-06 1.8 3.6121651785714283e-06 1.8 3.612723214285714e-06
+ 0.0 3.6194196428571426e-06 0.0 3.619977678571428e-06 1.8 3.630022321428571e-06 1.8
+ 3.630580357142857e-06 0.0 3.6372767857142854e-06 0.0 3.6378348214285713e-06 1.8 3.647879464285714e-06 1.8
+ 3.6484374999999997e-06 0.0 3.655133928571428e-06 0.0 3.655691964285714e-06 1.8 3.665736607142857e-06 1.8
+ 3.6662946428571425e-06 0.0 3.6729910714285713e-06 0.0 3.6735491071428568e-06 1.8 3.683035714285714e-06 1.8
+ 3.6835937499999998e-06 0.0 3.69140625e-06 0.0 3.6919642857142854e-06 1.8 3.700892857142857e-06 1.8 3.7014508928571425e-06
+ 0.0 3.7092633928571427e-06 0.0 3.709821428571428e-06 1.8 3.7187499999999998e-06 1.8
+ 3.7193080357142852e-06 0.0 3.7271205357142854e-06 0.0 3.7276785714285713e-06 1.8 3.7366071428571425e-06 1.8
+ 3.7371651785714284e-06 0.0 3.744977678571428e-06 0.0 3.745535714285714e-06 1.8 3.7544642857142853e-06 1.8
+ 3.755022321428571e-06 0.0 3.7628348214285714e-06 0.0 3.763392857142857e-06 1.8 3.7723214285714284e-06 1.8
+ 3.772879464285714e-06 0.0 3.780691964285714e-06 0.0 3.7812499999999996e-06 1.8 3.790178571428571e-06 1.8
+ 3.790736607142857e-06 0.0 3.798549107142857e-06 0.0 3.7991071428571428e-06 1.8 3.808035714285714e-06 1.8 3.80859375e-06
+ 0.0 3.81640625e-06 0.0 3.816964285714285e-06 1.8 3.825892857142857e-06 1.8 3.826450892857143e-06 0.0
+ 3.834263392857142e-06 0.0 3.834821428571428e-06 1.8 3.843749999999999e-06 1.8 3.844308035714285e-06 0.0
+ 3.8521205357142855e-06 0.0 3.852678571428571e-06 1.8 3.861607142857143e-06 1.8 3.8621651785714285e-06 0.0
+ 3.869977678571429e-06 0.0 3.870535714285714e-06 1.8 3.879464285714286e-06 1.8 3.880022321428571e-06 0.0
+ 3.887834821428571e-06 0.0 3.888392857142857e-06 1.8 3.897321428571428e-06 1.8 3.897879464285714e-06 0.0
+ 3.905691964285714e-06 0.0 3.90625e-06 1.8 3.915178571428571e-06 1.8 3.915736607142857e-06 0.0 3.9235491071428565e-06 0.0
+ 3.924107142857142e-06 1.8 3.933035714285714e-06 1.8 3.9335937499999995e-06 0.0 3.94140625e-06 0.0 3.9419642857142856e-06
+ 1.8 3.950892857142857e-06 1.8 3.951450892857143e-06 0.0 3.959263392857143e-06 0.0 3.959821428571428e-06
+ 1.8 3.96875e-06 1.8 3.969308035714286e-06 0.0 3.977120535714285e-06 0.0 3.977678571428571e-06 1.8
+ 3.986607142857142e-06 1.8 3.987165178571428e-06 0.0 3.994977678571428e-06 0.0 3.995535714285714e-06 1.8
+ 4.0039062499999995e-06 1.8 4.004464285714285e-06 0.0 4.0133928571428566e-06 0.0 4.0139508928571425e-06 1.8
+ 4.021763392857143e-06 1.8 4.0223214285714286e-06 0.0 4.03125e-06 0.0 4.031808035714286e-06 1.8 4.039620535714286e-06 1.8
+ 4.040178571428571e-06 0.0 4.049107142857143e-06 0.0 4.049665178571428e-06 1.8 4.057477678571428e-06 1.8
+ 4.058035714285714e-06 0.0 4.066964285714285e-06 0.0 4.067522321428571e-06 1.8 4.075334821428571e-06 1.8
+ 4.075892857142857e-06 0.0 4.084821428571428e-06 0.0 4.085379464285714e-06 1.8 4.093191964285714e-06 1.8
+ 4.0937499999999996e-06 0.0 4.102678571428571e-06 0.0 4.103236607142857e-06 1.8 4.111049107142857e-06 1.8
+ 4.111607142857143e-06 0.0 4.120535714285714e-06 0.0 4.12109375e-06 1.8 4.12890625e-06 1.8 4.129464285714285e-06 0.0
+ 4.138392857142857e-06 0.0 4.138950892857143e-06 1.8 4.146763392857142e-06 1.8 4.147321428571428e-06 0.0
+ 4.156249999999999e-06 0.0 4.156808035714285e-06 1.8 4.1646205357142855e-06 1.8 4.165178571428571e-06 0.0
+ 4.1741071428571426e-06 0.0 4.1746651785714285e-06 1.8 4.182477678571429e-06 1.8 4.183035714285714e-06 0.0
+ 4.191964285714286e-06 0.0 4.192522321428571e-06 1.8 4.200334821428571e-06 1.8 4.200892857142857e-06 0.0
+ 4.209821428571428e-06 0.0 4.210379464285714e-06 1.8 4.218191964285714e-06 1.8 4.21875e-06 0.0 4.227678571428571e-06 0.0
+ 4.228236607142857e-06 1.8 4.2360491071428565e-06 1.8 4.236607142857142e-06 0.0 4.245535714285714e-06 0.0
+ 4.2460937499999994e-06 1.8 4.25390625e-06 1.8 4.2544642857142855e-06 0.0 4.263392857142857e-06 0.0 4.263950892857143e-06
+ 1.8 4.271763392857143e-06 1.8 4.272321428571428e-06 0.0 4.28125e-06 0.0 4.281808035714286e-06 1.8
+ 4.289620535714285e-06 1.8 4.290178571428571e-06 0.0 4.299107142857142e-06 0.0 4.299665178571428e-06 1.8
+ 4.307477678571428e-06 1.8 4.308035714285714e-06 0.0 4.316964285714285e-06 0.0 4.317522321428571e-06 1.8
+ 4.3247767857142856e-06 1.8 4.3253348214285715e-06 0.0 4.335379464285714e-06 0.0 4.3359374999999995e-06 1.8
+ 4.342633928571428e-06 1.8 4.343191964285714e-06 0.0 4.353236607142857e-06 0.0 4.353794642857143e-06 1.8
+ 4.360491071428571e-06 1.8 4.361049107142857e-06 0.0 4.37109375e-06 0.0 4.371651785714285e-06 1.8 4.378348214285714e-06
+ 1.8 4.378906249999999e-06 0.0 4.388950892857142e-06 0.0 4.389508928571428e-06 1.8
+ 4.3962053571428565e-06 1.8 4.3967633928571425e-06 0.0 4.4068080357142854e-06 0.0 4.407366071428571e-06 1.8 4.4140625e-06
+ 1.8 4.414620535714286e-06 0.0 4.424665178571429e-06 0.0 4.425223214285714e-06 1.8 4.431919642857143e-06
+ 1.8 4.432477678571428e-06 0.0 4.442522321428571e-06 0.0 4.443080357142857e-06 1.8 4.449776785714285e-06
+ 1.8 4.450334821428571e-06 0.0 4.460379464285714e-06 0.0 4.4609375e-06 1.8 4.467633928571428e-06 1.8
+ 4.468191964285714e-06 0.0 4.4782366071428564e-06 0.0 4.478794642857142e-06 1.8 4.485491071428571e-06 1.8
+ 4.486049107142857e-06 0.0 4.49609375e-06 0.0 4.4966517857142855e-06 1.8 4.503348214285714e-06 1.8 4.50390625e-06 0.0
+ 4.513950892857143e-06 0.0 4.514508928571428e-06 1.8 4.521205357142857e-06 1.8 4.521763392857143e-06 0.0
+ 4.531808035714285e-06 0.0 4.532366071428571e-06 1.8 4.539062499999999e-06 1.8 4.539620535714285e-06 0.0
+ 4.549665178571428e-06 0.0 4.550223214285714e-06 1.8 4.5569196428571425e-06 1.8 4.5574776785714284e-06 0.0
+ 4.5675223214285714e-06 0.0 4.5680803571428565e-06 1.8 4.574776785714286e-06 1.8 4.575334821428571e-06 0.0
+ 4.585379464285714e-06 0.0 4.5859375e-06 1.8 4.592633928571428e-06 1.8 4.593191964285714e-06 0.0 4.603236607142857e-06 0.0
+ 4.603794642857143e-06 1.8 4.610491071428571e-06 1.8 4.611049107142857e-06 0.0 4.621093749999999e-06 0.0
+ 4.621651785714285e-06 1.8 4.628348214285714e-06 1.8 4.6289062499999994e-06 0.0 4.638950892857142e-06 0.0
+ 4.639508928571428e-06 1.8 4.646205357142857e-06 1.8 4.646763392857143e-06 0.0 4.656808035714286e-06 0.0
+ 4.6573660714285715e-06 1.8 4.6640625e-06 1.8 4.664620535714286e-06 0.0 4.675223214285714e-06 0.0 4.67578125e-06 1.8
+ 4.681361607142857e-06 1.8 4.681919642857142e-06 0.0 4.693080357142857e-06 0.0 4.693638392857143e-06 1.8
+ 4.6992187499999995e-06 1.8 4.699776785714285e-06 0.0 4.710937499999999e-06 0.0 4.711495535714285e-06 1.8
+ 4.717075892857143e-06 1.8 4.7176339285714285e-06 0.0 4.7287946428571425e-06 0.0 4.729352678571428e-06 1.8
+ 4.734933035714286e-06 1.8 4.735491071428571e-06 0.0 4.746651785714286e-06 0.0 4.747209821428571e-06 1.8
+ 4.752790178571428e-06 1.8 4.753348214285714e-06 0.0 4.764508928571428e-06 0.0 4.765066964285714e-06 1.8
+ 4.770647321428571e-06 1.8 4.771205357142857e-06 0.0 4.782366071428571e-06 0.0 4.782924107142857e-06 1.8
+ 4.788504464285714e-06 1.8 4.7890624999999995e-06 0.0 4.800223214285714e-06 0.0 4.800781249999999e-06 1.8
+ 4.806361607142857e-06 1.8 4.806919642857143e-06 0.0 4.818080357142857e-06 0.0 4.8186383928571425e-06 1.8 4.82421875e-06
+ 1.8 4.824776785714285e-06 0.0 4.8359375e-06 0.0 4.836495535714286e-06 1.8 4.842075892857142e-06 1.8
+ 4.842633928571428e-06 0.0 4.853794642857142e-06 0.0 4.854352678571428e-06 1.8 4.8599330357142854e-06 1.8
+ 4.860491071428571e-06 0.0 4.871651785714285e-06 0.0 4.872209821428571e-06 1.8 4.877790178571429e-06 1.8
+ 4.878348214285714e-06 0.0 4.8895089285714285e-06 0.0 4.8900669642857135e-06 1.8 4.895647321428571e-06 1.8
+ 4.896205357142857e-06 0.0 4.907366071428571e-06 0.0 4.907924107142857e-06 1.8 4.913504464285714e-06 1.8 4.9140625e-06 0.0
+ 4.925223214285714e-06 0.0 4.92578125e-06 1.8 4.9313616071428564e-06 1.8 4.931919642857142e-06 0.0 4.943080357142857e-06
+ 0.0 4.943638392857142e-06 1.8 4.94921875e-06 1.8 4.9497767857142855e-06 0.0 4.9609374999999995e-06 0.0
+ 4.961495535714285e-06 1.8 4.967075892857143e-06 1.8 4.967633928571428e-06 0.0 4.978794642857143e-06 0.0
+ 4.9793526785714285e-06 1.8 4.984933035714285e-06 1.8 4.985491071428571e-06 0.0 4.996651785714285e-06 0.0
+ 4.997209821428571e-06 1.8 5.002790178571428e-06 1.8 5.003348214285714e-06 0.0 5.014508928571428e-06 0.0
+ 5.015066964285714e-06 1.8 5.0206473214285714e-06 1.8 5.0212053571428565e-06 0.0 5.032366071428571e-06 0.0
+ 5.032924107142857e-06 1.8 5.038504464285714e-06 1.8 5.0390625e-06 0.0 5.050223214285714e-06 0.0 5.0507812499999995e-06
+ 1.8 5.056361607142857e-06 1.8 5.056919642857143e-06 0.0 5.068080357142857e-06 0.0 5.068638392857143e-06
+ 1.8 5.074218749999999e-06 1.8 5.074776785714285e-06 0.0 5.086495535714285e-06 0.0 5.087053571428571e-06
+ 1.8 5.0915178571428565e-06 1.8 5.092075892857142e-06 0.0 5.104352678571428e-06 0.0
+ 5.104910714285714e-06 1.8 5.109375e-06 1.8 5.109933035714286e-06 0.0 5.122209821428571e-06 0.0 5.122767857142856e-06 1.8
+ 5.127232142857143e-06 1.8 5.127790178571428e-06 0.0 5.140066964285714e-06 0.0 5.140625e-06 1.8 5.145089285714285e-06 1.8
+ 5.145647321428571e-06 0.0 5.157924107142857e-06 0.0 5.158482142857143e-06 1.8 5.162946428571428e-06 1.8
+ 5.163504464285714e-06 0.0 5.17578125e-06 0.0 5.176339285714285e-06 1.8 5.180803571428571e-06 1.8 5.1813616071428566e-06
+ 0.0 5.193638392857142e-06 0.0 5.194196428571428e-06 1.8 5.198660714285714e-06 1.8 5.19921875e-06 0.0
+ 5.2114955357142855e-06 0.0 5.2120535714285714e-06 1.8 5.216517857142857e-06 1.8 5.217075892857142e-06 0.0
+ 5.229352678571428e-06 0.0 5.229910714285714e-06 1.8 5.234374999999999e-06 1.8 5.234933035714285e-06 0.0
+ 5.247209821428571e-06 0.0 5.247767857142857e-06 1.8 5.2522321428571425e-06 1.8 5.252790178571428e-06 0.0
+ 5.265066964285714e-06 0.0 5.265624999999999e-06 1.8 5.270089285714286e-06 1.8 5.270647321428571e-06 0.0
+ 5.2829241071428565e-06 0.0 5.283482142857142e-06 1.8 5.287946428571428e-06 1.8 5.288504464285714e-06 0.0 5.30078125e-06
+ 0.0 5.301339285714286e-06 1.8 5.305803571428571e-06 1.8 5.306361607142857e-06 0.0 5.318638392857143e-06
+ 0.0 5.319196428571428e-06 1.8 5.3236607142857135e-06 1.8 5.324218749999999e-06 0.0
+ 5.336495535714285e-06 0.0 5.337053571428571e-06 1.8 5.341517857142857e-06 1.8 5.3420758928571426e-06 0.0
+ 5.354352678571428e-06 0.0 5.354910714285714e-06 1.8 5.359375e-06 1.8 5.359933035714286e-06 0.0 5.372209821428571e-06 0.0
+ 5.3727678571428566e-06 1.8 5.377232142857142e-06 1.8 5.377790178571428e-06 0.0 5.390066964285714e-06 0.0 5.390625e-06 1.8
+ 5.395089285714285e-06 1.8 5.395647321428571e-06 0.0 5.407924107142857e-06 0.0 5.408482142857142e-06 1.8
+ 5.4129464285714285e-06 1.8 5.4135044642857136e-06 0.0 5.425781249999999e-06 0.0 5.426339285714285e-06 1.8
+ 5.430803571428571e-06 1.8 5.431361607142857e-06 0.0 5.4436383928571425e-06 0.0 5.444196428571428e-06 1.8
+ 5.448660714285714e-06 1.8 5.44921875e-06 0.0 5.461495535714286e-06 0.0 5.462053571428571e-06 1.8 5.466517857142857e-06
+ 1.8 5.467075892857142e-06 0.0 5.479352678571428e-06 0.0 5.479910714285714e-06 1.8
+ 5.4843749999999995e-06 1.8 5.484933035714285e-06 0.0 5.497209821428571e-06 0.0 5.497767857142857e-06 1.8
+ 5.502232142857143e-06 1.8 5.5027901785714286e-06 0.0 5.5150669642857135e-06 0.0 5.515624999999999e-06 1.8
+ 5.520089285714285e-06 1.8 5.520647321428571e-06 0.0 5.532924107142857e-06 0.0 5.5334821428571426e-06 1.8
+ 5.537946428571428e-06 1.8 5.538504464285714e-06 0.0 5.55078125e-06 0.0 5.551339285714286e-06 1.8 5.555803571428571e-06
+ 1.8 5.556361607142856e-06 0.0 5.568638392857142e-06 0.0 5.569196428571428e-06 1.8 5.573660714285714e-06
+ 1.8 5.5742187499999995e-06 0.0 5.586495535714285e-06 0.0 5.587053571428571e-06 1.8
+ 5.591517857142857e-06 1.8 5.592075892857143e-06 0.0 5.6043526785714285e-06 0.0 5.6049107142857135e-06 1.8 5.609375e-06
+ 1.8 5.609933035714285e-06 0.0 5.622209821428571e-06 0.0 5.622767857142857e-06 1.8 5.627232142857142e-06
+ 1.8 5.627790178571428e-06 0.0 5.640066964285714e-06 0.0 5.640625e-06 1.8 5.6450892857142855e-06 1.8
+ 5.645647321428571e-06 0.0 5.657924107142857e-06 0.0 5.658482142857142e-06 1.8 5.662946428571428e-06 1.8
+ 5.663504464285714e-06 0.0 5.6757812499999995e-06 0.0 5.676339285714285e-06 1.8 5.680803571428571e-06 1.8
+ 5.681361607142857e-06 0.0 5.693638392857143e-06 0.0 5.6941964285714286e-06 1.8 5.698660714285714e-06 1.8
+ 5.699218749999999e-06 0.0 5.711495535714285e-06 0.0 5.712053571428571e-06 1.8 5.7165178571428565e-06 1.8
+ 5.717075892857142e-06 0.0 5.729352678571428e-06 0.0 5.729910714285714e-06 1.8 5.734375e-06 1.8 5.7349330357142855e-06 0.0
+ 5.747209821428571e-06 0.0 5.747767857142856e-06 1.8 5.752232142857143e-06 1.8 5.752790178571428e-06 0.0
+ 5.765066964285714e-06 0.0 5.7656249999999995e-06 1.8 5.770089285714285e-06 1.8 5.770647321428571e-06 0.0
+ 5.782924107142857e-06 0.0 5.783482142857143e-06 1.8 5.787946428571428e-06 1.8 5.788504464285714e-06 0.0 5.80078125e-06
+ 0.0 5.801339285714285e-06 1.8 5.805803571428571e-06 1.8 5.8063616071428565e-06 0.0
+ 5.818638392857142e-06 0.0 5.819196428571428e-06 1.8 5.823660714285714e-06 1.8 5.82421875e-06 0.0 5.8364955357142855e-06
+ 0.0 5.837053571428571e-06 1.8 5.841517857142857e-06 1.8 5.842075892857143e-06 0.0 5.854352678571428e-06
+ 0.0 5.854910714285714e-06 1.8 5.859374999999999e-06 1.8 5.859933035714285e-06 0.0 5.872209821428571e-06
+ 0.0 5.872767857142857e-06 1.8 5.8772321428571424e-06 1.8 5.877790178571428e-06 0.0
+ 5.890066964285714e-06 0.0 5.890624999999999e-06 1.8 5.895089285714286e-06 1.8 5.895647321428571e-06 0.0
+ 5.9079241071428564e-06 0.0 5.908482142857142e-06 1.8 5.912946428571428e-06 1.8 5.913504464285714e-06 0.0 5.92578125e-06
+ 0.0 5.9263392857142855e-06 1.8 5.930803571428571e-06 1.8 5.931361607142857e-06 0.0
+ 5.943638392857143e-06 0.0 5.944196428571428e-06 1.8 5.948660714285714e-06 1.8 5.949218749999999e-06 0.0
+ 5.961495535714285e-06 0.0 5.962053571428571e-06 1.8 5.966517857142857e-06 1.8 5.9670758928571425e-06 0.0
+ 5.979352678571428e-06 0.0 5.979910714285714e-06 1.8 5.984375e-06 1.8 5.984933035714286e-06 0.0 5.997209821428571e-06 0.0
+ 5.9977678571428565e-06 1.8 6.002232142857142e-06 1.8 6.002790178571428e-06 0.0 6.015066964285714e-06 0.0 6.015625e-06 1.8
+ 6.020089285714285e-06 1.8 6.020647321428571e-06 0.0 6.032924107142857e-06 0.0 6.033482142857142e-06 1.8
+ 6.0379464285714284e-06 1.8 6.0385044642857135e-06 0.0 6.050781249999999e-06 0.0 6.051339285714285e-06 1.8
+ 6.055803571428571e-06 1.8 6.056361607142857e-06 0.0 6.0686383928571424e-06 0.0 6.069196428571428e-06 1.8
+ 6.073660714285714e-06 1.8 6.07421875e-06 0.0 6.086495535714286e-06 0.0 6.087053571428571e-06 1.8 6.091517857142857e-06
+ 1.8 6.092075892857142e-06 0.0 6.104352678571428e-06 0.0 6.104910714285714e-06 1.8 6.109374999999999e-06
+ 1.8 6.109933035714285e-06 0.0 6.122209821428571e-06 0.0 6.122767857142857e-06 1.8 6.127232142857143e-06
+ 1.8 6.1277901785714285e-06 0.0 6.1400669642857134e-06 0.0 6.140624999999999e-06 1.8
+ 6.145089285714285e-06 1.8 6.145647321428571e-06 0.0 6.157924107142857e-06 0.0 6.1584821428571425e-06 1.8
+ 6.162946428571428e-06 1.8 6.163504464285714e-06 0.0 6.17578125e-06 0.0 6.176339285714286e-06 1.8 6.180803571428571e-06
+ 1.8 6.181361607142856e-06 0.0 6.193638392857142e-06 0.0 6.194196428571428e-06 1.8 6.198660714285714e-06
+ 1.8 6.1992187499999995e-06 0.0 6.211495535714285e-06 0.0 6.212053571428571e-06 1.8
+ 6.216517857142857e-06 1.8 6.217075892857143e-06 0.0 6.2293526785714284e-06 0.0 6.2299107142857135e-06 1.8 6.234375e-06
+ 1.8 6.234933035714285e-06 0.0 6.247209821428571e-06 0.0 6.247767857142857e-06 1.8 6.252232142857142e-06
+ 1.8 6.252790178571428e-06 0.0 6.265066964285714e-06 0.0 6.265625e-06 1.8 6.270089285714285e-06 1.8
+ 6.270647321428571e-06 0.0 6.282924107142857e-06 0.0 6.283482142857142e-06 1.8 6.287946428571428e-06 1.8
+ 6.288504464285714e-06 0.0 6.300781249999999e-06 0.0 6.301339285714285e-06 1.8 6.305803571428571e-06 1.8
+ 6.306361607142857e-06 0.0 6.318638392857143e-06 0.0 6.3191964285714285e-06 1.8 6.323660714285714e-06 1.8
+ 6.324218749999999e-06 0.0 6.336495535714285e-06 0.0 6.337053571428571e-06 1.8 6.341517857142856e-06 1.8
+ 6.342075892857142e-06 0.0 6.354352678571428e-06 0.0 6.354910714285714e-06 1.8 6.3593749999999996e-06 1.8
+ 6.3599330357142855e-06 0.0 6.372209821428571e-06 0.0 6.372767857142856e-06 1.8 6.377232142857143e-06 1.8
+ 6.377790178571428e-06 0.0 6.3900669642857136e-06 0.0 6.3906249999999995e-06 1.8 6.395089285714285e-06 1.8
+ 6.395647321428571e-06 0.0 6.407924107142857e-06 0.0 6.408482142857143e-06 1.8 6.412946428571428e-06 1.8
+ 6.413504464285714e-06 0.0 6.42578125e-06 0.0 6.426339285714285e-06 1.8 6.4308035714285706e-06 1.8 6.4313616071428565e-06
+ 0.0 6.443638392857142e-06 0.0 6.444196428571428e-06 1.8 6.448660714285714e-06 1.8 6.44921875e-06 0.0
+ 6.461495535714285e-06 0.0 6.462053571428571e-06 1.8 6.466517857142857e-06 1.8 6.467075892857143e-06 0.0
+ 6.479352678571428e-06 0.0 6.479910714285714e-06 1.8 6.484374999999999e-06 1.8 6.484933035714285e-06 0.0
+ 6.497209821428571e-06 0.0 6.497767857142857e-06 1.8 6.502232142857142e-06 1.8 6.502790178571428e-06 0.0
+ 6.515066964285714e-06 0.0 6.515624999999999e-06 1.8 6.5200892857142856e-06 1.8 6.520647321428571e-06 0.0
+ 6.532924107142856e-06 0.0 6.533482142857142e-06 1.8 6.537946428571428e-06 1.8 6.538504464285714e-06 0.0
+ 6.5507812499999996e-06 0.0 6.5513392857142855e-06 1.8 6.555803571428571e-06 1.8 6.556361607142857e-06 0.0
+ 6.568638392857143e-06 0.0 6.569196428571428e-06 1.8 6.573660714285714e-06 1.8 6.574218749999999e-06 0.0
+ 6.586495535714285e-06 0.0 6.587053571428571e-06 1.8 6.5915178571428565e-06 1.8 6.5920758928571425e-06 0.0
+ 6.604352678571428e-06 0.0 6.604910714285714e-06 1.8 6.609375e-06 1.8 6.609933035714286e-06 0.0 6.6222098214285706e-06 0.0
+ 6.6227678571428565e-06 1.8 6.627232142857142e-06 1.8 6.627790178571428e-06 0.0 6.640066964285714e-06 0.0 6.640625e-06 1.8
+ 6.645089285714285e-06 1.8 6.645647321428571e-06 0.0 6.657924107142857e-06 0.0 6.658482142857143e-06 1.8
+ 6.662946428571428e-06 1.8 6.6635044642857134e-06 0.0 6.675781249999999e-06 0.0 6.676339285714285e-06 1.8
+ 6.680803571428571e-06 1.8 6.681361607142857e-06 0.0 6.693638392857142e-06 0.0 6.694196428571428e-06 1.8
+ 6.698660714285714e-06 1.8 6.69921875e-06 0.0 6.7114955357142856e-06 0.0 6.712053571428571e-06 1.8 6.716517857142857e-06
+ 1.8 6.717075892857142e-06 0.0 6.729352678571428e-06 0.0 6.729910714285714e-06 1.8 6.734374999999999e-06
+ 1.8 6.734933035714285e-06 0.0 6.747209821428571e-06 0.0 6.747767857142857e-06 1.8
+ 6.7522321428571425e-06 1.8 6.7527901785714284e-06 0.0 6.765066964285714e-06 0.0 6.765624999999999e-06 1.8
+ 6.770089285714285e-06 1.8 6.770647321428571e-06 0.0 6.7829241071428565e-06 0.0 6.7834821428571425e-06 1.8
+ 6.787946428571428e-06 1.8 6.788504464285714e-06 0.0 6.80078125e-06 0.0 6.801339285714286e-06 1.8 6.805803571428571e-06
+ 1.8 6.806361607142856e-06 0.0 6.818638392857142e-06 0.0 6.819196428571428e-06 1.8
+ 6.8236607142857135e-06 1.8 6.8242187499999994e-06 0.0 6.836495535714285e-06 0.0 6.837053571428571e-06 1.8
+ 6.841517857142857e-06 1.8 6.842075892857143e-06 0.0 6.854352678571428e-06 0.0 6.8549107142857134e-06 1.8 6.859375e-06 1.8
+ 6.859933035714285e-06 0.0 6.872209821428571e-06 0.0 6.872767857142857e-06 1.8 6.877232142857142e-06 1.8
+ 6.877790178571428e-06 0.0 6.890066964285714e-06 0.0 6.890625e-06 1.8 6.895089285714285e-06 1.8 6.895647321428571e-06 0.0
+ 6.907924107142857e-06 0.0 6.908482142857142e-06 1.8 6.912946428571428e-06 1.8 6.913504464285714e-06 0.0
+ 6.9252232142857135e-06 0.0 6.925781249999999e-06 1.8 6.931361607142857e-06 1.8 6.931919642857143e-06 0.0
+ 6.943080357142857e-06 0.0 6.9436383928571425e-06 1.8 6.949218749999999e-06 1.8 6.949776785714285e-06 0.0 6.9609375e-06
+ 0.0 6.961495535714285e-06 1.8 6.967075892857142e-06 1.8 6.967633928571428e-06 0.0 6.978794642857142e-06
+ 0.0 6.979352678571428e-06 1.8 6.9849330357142854e-06 1.8 6.985491071428571e-06 0.0
+ 6.996651785714285e-06 0.0 6.997209821428571e-06 1.8 7.002790178571428e-06 1.8 7.003348214285714e-06 0.0
+ 7.0145089285714285e-06 0.0 7.0150669642857135e-06 1.8 7.020647321428571e-06 1.8 7.021205357142857e-06 0.0
+ 7.032366071428571e-06 0.0 7.032924107142857e-06 1.8 7.038504464285714e-06 1.8 7.039062499999999e-06 0.0
+ 7.050223214285714e-06 0.0 7.05078125e-06 1.8 7.056361607142856e-06 1.8 7.056919642857142e-06 0.0 7.068080357142856e-06
+ 0.0 7.068638392857142e-06 1.8 7.07421875e-06 1.8 7.0747767857142855e-06 0.0 7.0859374999999994e-06 0.0
+ 7.086495535714285e-06 1.8 7.092075892857143e-06 1.8 7.092633928571428e-06 0.0 7.103794642857143e-06 0.0
+ 7.104352678571428e-06 1.8 7.109933035714285e-06 1.8 7.110491071428571e-06 0.0 7.121651785714285e-06 0.0
+ 7.122209821428571e-06 1.8 7.127790178571428e-06 1.8 7.128348214285714e-06 0.0 7.139508928571428e-06 0.0
+ 7.140066964285714e-06 1.8 7.1456473214285706e-06 1.8 7.1462053571428565e-06 0.0 7.157366071428571e-06 0.0
+ 7.157924107142856e-06 1.8 7.163504464285714e-06 1.8 7.1640625e-06 0.0 7.175223214285714e-06 0.0 7.1757812499999995e-06
+ 1.8 7.181361607142857e-06 1.8 7.181919642857142e-06 0.0 7.193080357142857e-06 0.0 7.193638392857143e-06
+ 1.8 7.199218749999999e-06 1.8 7.199776785714285e-06 0.0 7.210937499999999e-06 0.0 7.211495535714285e-06
+ 1.8 7.217075892857142e-06 1.8 7.217633928571428e-06 0.0 7.228794642857142e-06 0.0 7.229352678571428e-06
+ 1.8 7.2349330357142856e-06 1.8 7.235491071428571e-06 0.0 7.2466517857142854e-06 0.0
+ 7.2472098214285705e-06 1.8 7.252790178571428e-06 1.8 7.253348214285714e-06 0.0 7.264508928571428e-06 0.0
+ 7.265066964285714e-06 1.8 7.270647321428571e-06 1.8 7.271205357142857e-06 0.0 7.282366071428571e-06 0.0
+ 7.282924107142857e-06 1.8 7.288504464285713e-06 1.8 7.289062499999999e-06 0.0 7.300223214285714e-06 0.0
+ 7.300781249999999e-06 1.8 7.3063616071428566e-06 1.8 7.3069196428571425e-06 0.0 7.318080357142856e-06 0.0
+ 7.318638392857142e-06 1.8 7.32421875e-06 1.8 7.324776785714285e-06 0.0 7.335379464285714e-06 0.0 7.3359375e-06 1.8
+ 7.342633928571428e-06 1.8 7.343191964285714e-06 0.0 7.353236607142857e-06 0.0 7.353794642857142e-06 1.8
+ 7.360491071428571e-06 1.8 7.361049107142856e-06 0.0 7.371093749999999e-06 0.0 7.371651785714285e-06 1.8
+ 7.3783482142857135e-06 1.8 7.378906249999999e-06 0.0 7.388950892857142e-06 0.0 7.389508928571428e-06 1.8
+ 7.396205357142857e-06 1.8 7.3967633928571425e-06 0.0 7.4068080357142855e-06 0.0 7.407366071428571e-06 1.8 7.4140625e-06
+ 1.8 7.414620535714285e-06 0.0 7.424665178571428e-06 0.0 7.425223214285714e-06 1.8 7.431919642857142e-06
+ 1.8 7.432477678571428e-06 0.0 7.442522321428571e-06 0.0 7.443080357142857e-06 1.8 7.449776785714285e-06
+ 1.8 7.450334821428571e-06 0.0 7.460379464285713e-06 0.0 7.460937499999999e-06 1.8
+ 7.4676339285714285e-06 1.8 7.4681919642857135e-06 0.0 7.4782366071428565e-06 0.0 7.478794642857142e-06 1.8
+ 7.485491071428571e-06 1.8 7.486049107142857e-06 0.0 7.49609375e-06 0.0 7.496651785714286e-06 1.8 7.503348214285714e-06
+ 1.8 7.50390625e-06 0.0 7.513950892857142e-06 0.0 7.514508928571428e-06 1.8 7.521205357142856e-06 1.8
+ 7.521763392857142e-06 0.0 7.531808035714285e-06 0.0 7.532366071428571e-06 1.8 7.5390624999999994e-06 1.8
+ 7.539620535714285e-06 0.0 7.549665178571428e-06 0.0 7.550223214285713e-06 1.8 7.556919642857143e-06 1.8
+ 7.557477678571428e-06 0.0 7.567522321428571e-06 0.0 7.5680803571428566e-06 1.8 7.574776785714285e-06 1.8
+ 7.575334821428571e-06 0.0 7.585379464285714e-06 0.0 7.5859375e-06 1.8 7.592633928571428e-06 1.8 7.593191964285714e-06 0.0
+ 7.603236607142857e-06 0.0 7.603794642857142e-06 1.8 7.610491071428571e-06 1.8 7.611049107142856e-06 0.0
+ 7.621093749999999e-06 0.0 7.621651785714285e-06 1.8 7.628348214285714e-06 1.8 7.6289062499999995e-06 0.0
+ 7.638950892857142e-06 0.0 7.639508928571428e-06 1.8 7.646205357142857e-06 1.8 7.646763392857142e-06 0.0
+ 7.656808035714285e-06 0.0 7.657366071428572e-06 1.8 7.664062499999999e-06 1.8 7.664620535714286e-06 0.0
+ 7.674665178571429e-06 0.0 7.675223214285714e-06 1.8 7.682477678571428e-06 1.8 7.683035714285713e-06 0.0
+ 7.691964285714284e-06 0.0 7.692522321428571e-06 1.8 7.70033482142857e-06 1.8 7.700892857142857e-06 0.0
+ 7.709821428571428e-06 0.0 7.710379464285713e-06 1.8 7.718191964285715e-06 1.8 7.71875e-06 0.0 7.72767857142857e-06 0.0
+ 7.728236607142856e-06 1.8 7.736049107142857e-06 1.8 7.736607142857142e-06 0.0 7.745535714285713e-06 0.0 7.74609375e-06
+ 1.8 7.75390625e-06 1.8 7.754464285714286e-06 0.0 7.763392857142857e-06 0.0 7.763950892857142e-06 1.8
+ 7.771763392857141e-06 1.8 7.772321428571428e-06 0.0 7.78125e-06 0.0 7.781808035714284e-06 1.8 7.789620535714286e-06 1.8
+ 7.79017857142857e-06 0.0 7.799107142857142e-06 0.0 7.799665178571428e-06 1.8 7.807477678571428e-06 1.8
+ 7.808035714285713e-06 0.0 7.816964285714286e-06 0.0 7.81752232142857e-06 1.8 7.82533482142857e-06 1.8
+ 7.825892857142857e-06 0.0 7.834821428571428e-06 0.0 7.835379464285713e-06 1.8 7.843191964285714e-06 1.8 7.84375e-06 0.0
+ 7.85267857142857e-06 0.0 7.853236607142857e-06 1.8 7.861049107142856e-06 1.8 7.861607142857142e-06 0.0
+ 7.870535714285714e-06 0.0 7.87109375e-06 1.8 7.878906249999999e-06 1.8 7.879464285714286e-06 0.0 7.888392857142857e-06
+ 0.0 7.888950892857142e-06 1.8 7.896763392857143e-06 1.8 7.897321428571428e-06 0.0 7.906249999999999e-06
+ 0.0 7.906808035714286e-06 1.8 7.914620535714285e-06 1.8 7.91517857142857e-06 0.0 7.924107142857143e-06
+ 0.0 7.924665178571428e-06 1.8 7.932477678571427e-06 1.8 7.933035714285714e-06 0.0 7.941964285714285e-06
+ 0.0 7.94252232142857e-06 1.8 7.950334821428571e-06 1.8 7.950892857142857e-06 0.0 7.959821428571428e-06
+ 0.0 7.960379464285714e-06 1.8 7.968191964285714e-06 1.8 7.968749999999999e-06 0.0 7.97767857142857e-06
+ 0.0 7.978236607142857e-06 1.8 7.986049107142856e-06 1.8 7.986607142857143e-06 0.0 7.995535714285714e-06
+ 0.0 7.996093749999999e-06 1.8 8.004464285714285e-06 1.8 8.00502232142857e-06 0.0 8.012834821428571e-06
+ 0.0 8.013392857142856e-06 1.8 8.022321428571428e-06 1.8 8.022879464285714e-06 0.0 8.030691964285714e-06
+ 0.0 8.031249999999999e-06 1.8 8.040178571428572e-06 1.8 8.040736607142857e-06 0.0 8.048549107142856e-06
+ 0.0 8.049107142857143e-06 1.8 8.058035714285714e-06 1.8 8.058593749999999e-06 0.0 8.06640625e-06 0.0
+ 8.066964285714285e-06 1.8 8.075892857142856e-06 1.8 8.076450892857143e-06 0.0 8.084263392857142e-06 0.0
+ 8.084821428571427e-06 1.8 8.09375e-06 1.8 8.094308035714285e-06 0.0 8.102120535714285e-06 0.0 8.102678571428571e-06 1.8
+ 8.111607142857143e-06 1.8 8.112165178571428e-06 0.0 8.119977678571429e-06 0.0 8.120535714285714e-06 1.8
+ 8.129464285714285e-06 1.8 8.130022321428572e-06 0.0 8.137834821428571e-06 0.0 8.138392857142856e-06 1.8
+ 8.147321428571427e-06 1.8 8.147879464285714e-06 0.0 8.155691964285713e-06 0.0 8.15625e-06 1.8 8.165178571428571e-06 1.8
+ 8.165736607142856e-06 0.0 8.173549107142857e-06 0.0 8.174107142857142e-06 1.8 8.183035714285714e-06 1.8
+ 8.183593749999999e-06 0.0 8.19140625e-06 0.0 8.191964285714285e-06 1.8 8.200892857142856e-06 1.8 8.201450892857143e-06
+ 0.0 8.209263392857142e-06 0.0 8.209821428571429e-06 1.8 8.21875e-06 1.8 8.219308035714285e-06 0.0
+ 8.227120535714284e-06 0.0 8.227678571428571e-06 1.8 8.236607142857142e-06 1.8 8.237165178571427e-06 0.0
+ 8.244977678571428e-06 0.0 8.245535714285713e-06 1.8 8.254464285714285e-06 1.8 8.255022321428571e-06 0.0
+ 8.26283482142857e-06 0.0 8.263392857142857e-06 1.8 8.272321428571429e-06 1.8 8.272879464285714e-06 0.0
+ 8.280691964285713e-06 0.0 8.28125e-06 1.8 8.290178571428571e-06 1.8 8.290736607142856e-06 0.0 8.298549107142857e-06 0.0
+ 8.299107142857142e-06 1.8 8.308035714285713e-06 1.8 8.30859375e-06 0.0 8.31640625e-06 0.0 8.316964285714284e-06 1.8
+ 8.326450892857142e-06 1.8 8.327008928571427e-06 0.0 8.333705357142857e-06 0.0 8.334263392857142e-06 1.8
+ 8.344308035714285e-06 1.8 8.344866071428571e-06 0.0 8.351562499999999e-06 0.0 8.352120535714286e-06 1.8
+ 8.362165178571429e-06 1.8 8.362723214285714e-06 0.0 8.369419642857143e-06 0.0 8.369977678571428e-06 1.8
+ 8.380022321428571e-06 1.8 8.380580357142856e-06 0.0 8.387276785714285e-06 0.0 8.38783482142857e-06 1.8
+ 8.397879464285713e-06 1.8 8.3984375e-06 0.0 8.405133928571428e-06 0.0 8.405691964285714e-06 1.8 8.415736607142857e-06 1.8
+ 8.416294642857142e-06 0.0 8.422991071428572e-06 0.0 8.423549107142857e-06 1.8 8.43359375e-06 1.8 8.434151785714285e-06
+ 0.0 8.440848214285714e-06 0.0 8.441406249999999e-06 1.8 8.451450892857142e-06 1.8 8.452008928571429e-06
+ 0.0 8.458705357142856e-06 0.0 8.459263392857143e-06 1.8 8.469308035714286e-06 1.8 8.469866071428571e-06
+ 0.0 8.4765625e-06 0.0 8.477120535714285e-06 1.8 8.487165178571428e-06 1.8 8.487723214285713e-06 0.0
+ 8.494419642857143e-06 0.0 8.494977678571428e-06 1.8 8.50502232142857e-06 1.8 8.505580357142857e-06 0.0
+ 8.512276785714285e-06 0.0 8.512834821428572e-06 1.8 8.522879464285713e-06 1.8 8.5234375e-06 0.0 8.530133928571427e-06 0.0
+ 8.530691964285714e-06 1.8 8.540736607142857e-06 1.8 8.541294642857142e-06 0.0 8.547991071428571e-06 0.0
+ 8.548549107142856e-06 1.8 8.55859375e-06 1.8 8.559151785714284e-06 0.0 8.565848214285714e-06 0.0 8.566406249999999e-06
+ 1.8 8.576450892857142e-06 1.8 8.577008928571428e-06 0.0 8.583705357142856e-06 0.0 8.584263392857143e-06
+ 1.8 8.594308035714286e-06 1.8 8.59486607142857e-06 0.0 8.6015625e-06 0.0 8.602120535714285e-06 1.8
+ 8.612165178571428e-06 1.8 8.612723214285713e-06 0.0 8.619419642857142e-06 0.0 8.619977678571427e-06 1.8
+ 8.63002232142857e-06 1.8 8.630580357142857e-06 0.0 8.637276785714285e-06 0.0 8.637834821428571e-06 1.8
+ 8.647879464285714e-06 1.8 8.6484375e-06 0.0 8.655133928571429e-06 0.0 8.655691964285714e-06 1.8 8.665736607142857e-06 1.8
+ 8.666294642857142e-06 0.0 8.672433035714286e-06 0.0 8.672991071428571e-06 1.8 8.684151785714286e-06 1.8
+ 8.68470982142857e-06 0.0 8.690290178571428e-06 0.0 8.690848214285713e-06 1.8 8.702008928571428e-06 1.8
+ 8.702566964285713e-06 0.0 8.70814732142857e-06 0.0 8.708705357142857e-06 1.8 8.71986607142857e-06 1.8
+ 8.720424107142857e-06 0.0 8.726004464285714e-06 0.0 8.7265625e-06 1.8 8.737723214285714e-06 1.8 8.73828125e-06 0.0
+ 8.743861607142857e-06 0.0 8.744419642857142e-06 1.8 8.755580357142857e-06 1.8 8.756138392857142e-06 0.0
+ 8.761718749999999e-06 0.0 8.762276785714286e-06 1.8 8.773437499999999e-06 1.8 8.773995535714286e-06 0.0
+ 8.779575892857141e-06 0.0 8.780133928571428e-06 1.8 8.791294642857143e-06 1.8 8.791852678571428e-06 0.0
+ 8.797433035714285e-06 0.0 8.79799107142857e-06 1.8 8.809151785714285e-06 1.8 8.80970982142857e-06 0.0
+ 8.815290178571428e-06 0.0 8.815848214285713e-06 1.8 8.827008928571428e-06 1.8 8.827566964285714e-06 0.0
+ 8.83314732142857e-06 0.0 8.833705357142857e-06 1.8 8.844866071428572e-06 1.8 8.845424107142857e-06 0.0
+ 8.851004464285714e-06 0.0 8.8515625e-06 1.8 8.862723214285714e-06 1.8 8.863281249999999e-06 0.0 8.868861607142856e-06 0.0
+ 8.869419642857141e-06 1.8 8.880580357142856e-06 1.8 8.881138392857143e-06 0.0 8.886718749999999e-06 0.0
+ 8.887276785714286e-06 1.8 8.898437499999999e-06 1.8 8.898995535714285e-06 0.0 8.904575892857143e-06 0.0
+ 8.905133928571428e-06 1.8 8.916294642857143e-06 1.8 8.916852678571428e-06 0.0 8.922433035714285e-06 0.0
+ 8.92299107142857e-06 1.8 8.934151785714285e-06 1.8 8.93470982142857e-06 0.0 8.940290178571427e-06 0.0
+ 8.940848214285714e-06 1.8 8.952008928571427e-06 1.8 8.952566964285714e-06 0.0 8.958147321428571e-06 0.0
+ 8.958705357142856e-06 1.8 8.969866071428571e-06 1.8 8.970424107142856e-06 0.0 8.976004464285714e-06 0.0
+ 8.976562499999999e-06 1.8 8.987723214285714e-06 1.8 8.988281249999999e-06 0.0 8.993861607142856e-06 0.0
+ 8.994419642857143e-06 1.8 9.005580357142856e-06 1.8 9.006138392857143e-06 0.0 9.01171875e-06 0.0 9.012276785714285e-06
+ 1.8 9.0234375e-06 1.8 9.023995535714285e-06 0.0 9.029575892857142e-06 0.0 9.030133928571427e-06 1.8
+ 9.041294642857142e-06 1.8 9.041852678571427e-06 0.0 9.047433035714285e-06 0.0 9.047991071428571e-06 1.8
+ 9.059151785714285e-06 1.8 9.059709821428571e-06 0.0 9.065290178571429e-06 0.0 9.065848214285714e-06 1.8
+ 9.077008928571429e-06 1.8 9.077566964285714e-06 0.0 9.082589285714284e-06 0.0 9.083147321428571e-06 1.8
+ 9.095424107142856e-06 1.8 9.095982142857143e-06 0.0 9.100446428571428e-06 0.0 9.101004464285713e-06 1.8 9.11328125e-06
+ 1.8 9.113839285714285e-06 0.0 9.11830357142857e-06 0.0 9.118861607142856e-06 1.8 9.131138392857142e-06
+ 1.8 9.131696428571427e-06 0.0 9.136160714285713e-06 0.0 9.13671875e-06 1.8 9.148995535714285e-06 1.8
+ 9.149553571428571e-06 0.0 9.154017857142857e-06 0.0 9.154575892857142e-06 1.8 9.166852678571429e-06 1.8
+ 9.167410714285714e-06 0.0 9.171875e-06 0.0 9.172433035714284e-06 1.8 9.184709821428571e-06 1.8 9.185267857142856e-06 0.0
+ 9.189732142857142e-06 0.0 9.190290178571428e-06 1.8 9.202566964285713e-06 1.8 9.203125e-06 0.0 9.207589285714286e-06 0.0
+ 9.20814732142857e-06 1.8 9.220424107142856e-06 1.8 9.220982142857142e-06 0.0 9.225446428571428e-06 0.0
+ 9.226004464285713e-06 1.8 9.23828125e-06 1.8 9.238839285714285e-06 0.0 9.24330357142857e-06 0.0 9.243861607142857e-06 1.8
+ 9.256138392857142e-06 1.8 9.256696428571429e-06 0.0 9.261160714285714e-06 0.0 9.26171875e-06 1.8 9.273995535714284e-06
+ 1.8 9.274553571428571e-06 0.0 9.279017857142857e-06 0.0 9.279575892857142e-06 1.8 9.291852678571428e-06
+ 1.8 9.292410714285713e-06 0.0 9.296874999999999e-06 0.0 9.297433035714286e-06 1.8 9.30970982142857e-06
+ 1.8 9.310267857142856e-06 0.0 9.314732142857143e-06 0.0 9.315290178571428e-06 1.8 9.327566964285713e-06
+ 1.8 9.328125e-06 0.0 9.332589285714285e-06 0.0 9.33314732142857e-06 1.8 9.345424107142857e-06 1.8
+ 9.345982142857142e-06 0.0 9.350446428571428e-06 0.0 9.351004464285714e-06 1.8 9.36328125e-06 1.8 9.363839285714284e-06
+ 0.0 9.36830357142857e-06 0.0 9.368861607142857e-06 1.8 9.381138392857142e-06 1.8 9.381696428571428e-06
+ 0.0 9.386160714285714e-06 0.0 9.386718749999999e-06 1.8 9.398995535714286e-06 1.8 9.39955357142857e-06
+ 0.0 9.404017857142856e-06 0.0 9.404575892857141e-06 1.8 9.416852678571428e-06 1.8 9.417410714285713e-06
+ 0.0 9.421874999999999e-06 0.0 9.422433035714285e-06 1.8 9.43470982142857e-06 1.8 9.435267857142857e-06
+ 0.0 9.439732142857143e-06 0.0 9.440290178571428e-06 1.8 9.452566964285714e-06 1.8 9.453125e-06 0.0
+ 9.457589285714285e-06 0.0 9.45814732142857e-06 1.8 9.470424107142857e-06 1.8 9.470982142857142e-06 0.0
+ 9.475446428571427e-06 0.0 9.476004464285714e-06 1.8 9.488281249999999e-06 1.8 9.488839285714286e-06 0.0
+ 9.493303571428571e-06 0.0 9.493861607142856e-06 1.8 9.506138392857143e-06 1.8 9.506696428571428e-06 0.0
+ 9.511160714285714e-06 0.0 9.511718749999999e-06 1.8 9.523995535714285e-06 1.8 9.52455357142857e-06 0.0
+ 9.529017857142856e-06 0.0 9.529575892857143e-06 1.8 9.541852678571428e-06 1.8 9.542410714285714e-06 0.0 9.546875e-06 0.0
+ 9.547433035714285e-06 1.8 9.55970982142857e-06 1.8 9.560267857142857e-06 0.0 9.564732142857142e-06 0.0
+ 9.565290178571427e-06 1.8 9.577566964285714e-06 1.8 9.578124999999999e-06 0.0 9.582589285714285e-06 0.0
+ 9.583147321428571e-06 1.8 9.595424107142856e-06 1.8 9.595982142857141e-06 0.0 9.600446428571429e-06 0.0
+ 9.601004464285714e-06 1.8 9.613281249999999e-06 1.8 9.613839285714285e-06 0.0 9.618303571428571e-06 0.0
+ 9.618861607142856e-06 1.8 9.631138392857143e-06 1.8 9.631696428571428e-06 0.0 9.636160714285713e-06 0.0 9.63671875e-06
+ 1.8 9.648995535714285e-06 1.8 9.64955357142857e-06 0.0 9.654017857142857e-06 0.0 9.654575892857142e-06
+ 1.8 9.666852678571427e-06 1.8 9.667410714285714e-06 0.0 9.671875e-06 0.0 9.672433035714285e-06 1.8
+ 9.684709821428571e-06 1.8 9.685267857142856e-06 0.0 9.689732142857142e-06 0.0 9.690290178571429e-06 1.8
+ 9.702566964285714e-06 1.8 9.703124999999999e-06 0.0 9.707589285714284e-06 0.0 9.708147321428571e-06 1.8
+ 9.720424107142856e-06 1.8 9.720982142857143e-06 0.0 9.725446428571428e-06 0.0 9.726004464285713e-06 1.8 9.73828125e-06
+ 1.8 9.738839285714285e-06 0.0 9.74330357142857e-06 0.0 9.743861607142856e-06 1.8 9.756138392857142e-06
+ 1.8 9.756696428571427e-06 0.0 9.761160714285713e-06 0.0 9.76171875e-06 1.8 9.773995535714285e-06 1.8
+ 9.774553571428571e-06 0.0 9.779017857142857e-06 0.0 9.779575892857142e-06 1.8 9.791852678571429e-06 1.8
+ 9.792410714285714e-06 0.0 9.796875e-06 0.0 9.797433035714284e-06 1.8 9.809709821428571e-06 1.8 9.810267857142856e-06 0.0
+ 9.814732142857142e-06 0.0 9.815290178571428e-06 1.8 9.827566964285713e-06 1.8 9.828125e-06 0.0 9.832589285714286e-06 0.0
+ 9.83314732142857e-06 1.8 9.845424107142856e-06 1.8 9.845982142857142e-06 0.0 9.850446428571428e-06 0.0
+ 9.851004464285713e-06 1.8 9.86328125e-06 1.8 9.863839285714285e-06 0.0 9.86830357142857e-06 0.0 9.868861607142857e-06 1.8
+ 9.881138392857142e-06 1.8 9.881696428571429e-06 0.0 9.886160714285714e-06 0.0 9.88671875e-06 1.8 9.898995535714284e-06
+ 1.8 9.899553571428571e-06 0.0 9.904017857142857e-06 0.0 9.904575892857142e-06 1.8 9.916852678571428e-06
+ 1.8 9.917410714285713e-06 0.0 9.921874999999999e-06 0.0 9.922433035714286e-06 1.8 9.93470982142857e-06
+ 1.8 9.935267857142856e-06 0.0 9.939732142857143e-06 0.0 9.940290178571428e-06 1.8 9.952566964285713e-06
+ 1.8 9.953125e-06 0.0 9.957589285714285e-06 0.0 9.95814732142857e-06 1.8 9.970424107142857e-06 1.8
+ 9.970982142857142e-06 0.0 9.975446428571428e-06 0.0 9.976004464285714e-06 1.8 9.98828125e-06 1.8 9.988839285714284e-06
+ 0.0 9.99330357142857e-06 0.0 9.993861607142857e-06 1.8 1.0006138392857142e-05 1.8
+ 1.0006696428571428e-05 0.0 1.0011160714285714e-05 0.0 1.0011718749999999e-05 1.8 1.0023995535714286e-05 1.8
+ 1.002455357142857e-05 0.0 1.0029017857142856e-05 0.0 1.0029575892857141e-05 1.8 1.0041852678571428e-05 1.8
+ 1.0042410714285713e-05 0.0 1.0046874999999999e-05 0.0 1.0047433035714285e-05 1.8 1.005970982142857e-05 1.8
+ 1.0060267857142857e-05 0.0 1.0064732142857143e-05 0.0 1.0065290178571428e-05 1.8 1.0077566964285714e-05 1.8 1.0078125e-05
+ 0.0 1.0082589285714285e-05 0.0 1.008314732142857e-05 1.8 1.0095424107142857e-05 1.8
+ 1.0095982142857142e-05 0.0 1.0100446428571427e-05 0.0 1.0101004464285714e-05 1.8 1.0113281249999999e-05 1.8
+ 1.0113839285714286e-05 0.0 1.0118303571428571e-05 0.0 1.0118861607142856e-05 1.8 1.0131138392857143e-05 1.8
+ 1.0131696428571428e-05 0.0 1.0136160714285714e-05 0.0 1.0136718749999999e-05 1.8 1.0148995535714285e-05 1.8
+ 1.014955357142857e-05 0.0 1.0154017857142856e-05 0.0 1.0154575892857143e-05 1.8 1.0166852678571428e-05 1.8
+ 1.0167410714285714e-05 0.0 1.0171875e-05 0.0 1.0172433035714285e-05 1.8 1.018470982142857e-05 1.8 1.0185267857142857e-05
+ 0.0 1.0189732142857142e-05 0.0 1.0190290178571427e-05 1.8 1.0202566964285714e-05 1.8
+ 1.0203124999999999e-05 0.0 1.0207589285714285e-05 0.0 1.0208147321428571e-05 1.8 1.0220424107142856e-05 1.8
+ 1.0220982142857141e-05 0.0 1.0225446428571429e-05 0.0 1.0226004464285714e-05 1.8 1.0238281249999999e-05 1.8
+ 1.0238839285714285e-05 0.0 1.0243303571428571e-05 0.0 1.0243861607142856e-05 1.8 1.0256138392857143e-05 1.8
+ 1.0256696428571428e-05 0.0 1.0261160714285713e-05 0.0 1.026171875e-05 1.8 1.0273995535714285e-05 1.8 1.027455357142857e-05
+ 0.0 1.0279017857142857e-05 0.0 1.0279575892857142e-05 1.8 1.0291852678571427e-05 1.8
+ 1.0292410714285714e-05 0.0 1.0296875e-05 0.0 1.0297433035714285e-05 1.8 1.0309709821428571e-05 1.8 1.0310267857142856e-05
+ 0.0 1.0314732142857142e-05 0.0 1.0315290178571429e-05 1.8 1.0327566964285714e-05 1.8
+ 1.0328124999999999e-05 0.0 1.0332589285714284e-05 0.0 1.0333147321428571e-05 1.8 1.0345424107142856e-05 1.8
+ 1.0345982142857143e-05 0.0 1.0350446428571428e-05 0.0 1.0351004464285713e-05 1.8 1.036328125e-05 1.8
+ 1.0363839285714285e-05 0.0 1.036830357142857e-05 0.0 1.0368861607142856e-05 1.8 1.0381138392857142e-05 1.8
+ 1.0381696428571427e-05 0.0 1.0386160714285713e-05 0.0 1.038671875e-05 1.8 1.0398995535714285e-05 1.8
+ 1.0399553571428571e-05 0.0 1.0404017857142857e-05 0.0 1.0404575892857142e-05 1.8 1.0416852678571429e-05 1.8
+ 1.0417410714285714e-05 0.0 1.0421875e-05 0.0 1.0422433035714284e-05 1.8 1.0434709821428571e-05 1.8 1.0435267857142856e-05
+ 0.0 1.0439732142857142e-05 0.0 1.0440290178571428e-05 1.8 1.0452566964285713e-05 1.8 1.0453125e-05 0.0
+ 1.0457589285714286e-05 0.0 1.045814732142857e-05 1.8 1.0470424107142857e-05 1.8 1.0470982142857142e-05 0.0
+ 1.0475446428571428e-05 0.0 1.0476004464285713e-05 1.8 1.048828125e-05 1.8 1.0488839285714285e-05 0.0 1.049330357142857e-05
+ 0.0 1.0493861607142857e-05 1.8 1.0506138392857142e-05 1.8 1.0506696428571429e-05 0.0
+ 1.0511160714285714e-05 0.0 1.051171875e-05 1.8 1.0523995535714284e-05 1.8 1.0524553571428571e-05 0.0
+ 1.0529017857142857e-05 0.0 1.0529575892857142e-05 1.8 1.0541852678571428e-05 1.8 1.0542410714285713e-05 0.0
+ 1.0546874999999999e-05 0.0 1.0547433035714286e-05 1.8 1.055970982142857e-05 1.8 1.0560267857142856e-05 0.0
+ 1.0564732142857143e-05 0.0 1.0565290178571428e-05 1.8 1.0577566964285713e-05 1.8 1.0578125e-05 0.0 1.0582589285714285e-05
+ 0.0 1.058314732142857e-05 1.8 1.0595424107142857e-05 1.8 1.0595982142857142e-05 0.0
+ 1.0600446428571428e-05 0.0 1.0601004464285714e-05 1.8 1.061328125e-05 1.8 1.0613839285714284e-05 0.0 1.061830357142857e-05
+ 0.0 1.0618861607142857e-05 1.8 1.0631138392857142e-05 1.8 1.0631696428571428e-05 0.0
+ 1.0636160714285714e-05 0.0 1.0636718749999999e-05 1.8 1.0648995535714286e-05 1.8 1.064955357142857e-05 0.0
+ 1.0654017857142856e-05 0.0 1.0654575892857141e-05 1.8 1.0666852678571428e-05 1.8 1.0667410714285713e-05 0.0
+ 1.0671874999999999e-05 0.0 1.0672433035714285e-05 1.8 1.068470982142857e-05 1.8 1.0685267857142857e-05 0.0
+ 1.0689732142857143e-05 0.0 1.0690290178571428e-05 1.8 1.0702566964285714e-05 1.8 1.0703125e-05 0.0 1.0707589285714285e-05
+ 0.0 1.070814732142857e-05 1.8 1.0720424107142857e-05 1.8 1.0720982142857142e-05 0.0
+ 1.0725446428571427e-05 0.0 1.0726004464285714e-05 1.8 1.0738281249999999e-05 1.8 1.0738839285714286e-05 0.0
+ 1.0743303571428571e-05 0.0 1.0743861607142856e-05 1.8 1.0756138392857143e-05 1.8 1.0756696428571428e-05 0.0
+ 1.0761160714285714e-05 0.0 1.0761718749999999e-05 1.8 1.0773995535714285e-05 1.8 1.077455357142857e-05 0.0
+ 1.0779017857142856e-05 0.0 1.0779575892857143e-05 1.8 1.0791852678571428e-05 1.8 1.0792410714285714e-05 0.0 1.0796875e-05
+ 0.0 1.0797433035714285e-05 1.8 1.080970982142857e-05 1.8 1.0810267857142857e-05 0.0
+ 1.0814732142857142e-05 0.0 1.0815290178571427e-05 1.8 1.0827566964285714e-05 1.8 1.0828124999999999e-05 0.0
+ 1.0832589285714285e-05 0.0 1.0833147321428571e-05 1.8 1.0845424107142856e-05 1.8 1.0845982142857141e-05 0.0
+ 1.0850446428571429e-05 0.0 1.0851004464285714e-05 1.8 1.0863281249999999e-05 1.8 1.0863839285714285e-05 0.0
+ 1.086830357142857e-05 0.0 1.0868861607142856e-05 1.8 1.0881138392857143e-05 1.8 1.0881696428571428e-05 0.0
+ 1.0886160714285713e-05 0.0 1.088671875e-05 1.8 1.0898995535714285e-05 1.8 1.089955357142857e-05 0.0 1.0904017857142857e-05
+ 0.0 1.0904575892857142e-05 1.8 1.0916852678571427e-05 1.8 1.0917410714285714e-05 0.0
+ 1.0922433035714285e-05 0.0 1.0922991071428571e-05 1.8 1.0934151785714284e-05 1.8 1.0934709821428571e-05 0.0
+ 1.0940290178571429e-05 0.0 1.0940848214285714e-05 1.8 1.0952008928571428e-05 1.8 1.0952566964285714e-05 0.0
+ 1.0958147321428571e-05 0.0 1.0958705357142856e-05 1.8 1.096986607142857e-05 1.8 1.0970424107142856e-05 0.0
+ 1.0976004464285713e-05 0.0 1.09765625e-05 1.8 1.0987723214285713e-05 1.8 1.098828125e-05 0.0 1.0993861607142856e-05 0.0
+ 1.0994419642857142e-05 1.8 1.1005580357142857e-05 1.8 1.1006138392857142e-05 0.0 1.101171875e-05 0.0
+ 1.1012276785714285e-05 1.8 1.10234375e-05 1.8 1.1023995535714284e-05 0.0 1.1029575892857142e-05 0.0 1.1030133928571427e-05
+ 1.8 1.1041294642857142e-05 1.8 1.1041852678571429e-05 0.0 1.1047433035714284e-05 0.0
+ 1.1047991071428571e-05 1.8 1.1059151785714284e-05 1.8 1.105970982142857e-05 0.0 1.1065290178571428e-05 0.0
+ 1.1065848214285713e-05 1.8 1.1077008928571428e-05 1.8 1.1077566964285713e-05 0.0 1.108314732142857e-05 0.0
+ 1.1083705357142856e-05 1.8 1.109486607142857e-05 1.8 1.1095424107142857e-05 0.0 1.1101004464285713e-05 0.0 1.11015625e-05
+ 1.8 1.1112723214285713e-05 1.8 1.111328125e-05 0.0 1.1118861607142857e-05 0.0 1.1119419642857142e-05
+ 1.8 1.1130580357142857e-05 1.8 1.1131138392857142e-05 0.0 1.113671875e-05 0.0 1.1137276785714284e-05
+ 1.8 1.1148437499999999e-05 1.8 1.1148995535714284e-05 0.0 1.1154575892857142e-05 0.0
+ 1.1155133928571428e-05 1.8 1.1166294642857141e-05 1.8 1.1166852678571428e-05 0.0 1.1172433035714286e-05 0.0
+ 1.117299107142857e-05 1.8 1.1184151785714285e-05 1.8 1.118470982142857e-05 0.0 1.1190290178571428e-05 0.0
+ 1.1190848214285713e-05 1.8 1.1202008928571428e-05 1.8 1.1202566964285713e-05 0.0 1.120814732142857e-05 0.0
+ 1.1208705357142857e-05 1.8 1.121986607142857e-05 1.8 1.1220424107142857e-05 0.0 1.1226004464285714e-05 0.0 1.12265625e-05
+ 1.8 1.1237723214285714e-05 1.8 1.123828125e-05 0.0 1.1243861607142857e-05 0.0 1.1244419642857142e-05
+ 1.8 1.1255580357142856e-05 1.8 1.1256138392857141e-05 0.0 1.1261718749999999e-05 0.0
+ 1.1262276785714286e-05 1.8 1.1273437499999999e-05 1.8 1.1273995535714285e-05 0.0 1.1279575892857143e-05 0.0
+ 1.1280133928571428e-05 1.8 1.1291294642857143e-05 1.8 1.1291852678571428e-05 0.0 1.1297433035714285e-05 0.0
+ 1.129799107142857e-05 1.8 1.1309151785714285e-05 1.8 1.130970982142857e-05 0.0 1.1315290178571428e-05 0.0
+ 1.1315848214285714e-05 1.8 1.1327008928571427e-05 1.8 1.1327566964285714e-05 0.0 1.1333705357142857e-05 0.0
+ 1.1334263392857142e-05 1.8 1.1344308035714285e-05 1.8 1.1344866071428571e-05 0.0 1.1351562499999999e-05 0.0
+ 1.1352120535714286e-05 1.8 1.1362165178571427e-05 1.8 1.1362723214285714e-05 0.0 1.1369419642857141e-05 0.0
+ 1.1369977678571428e-05 1.8 1.1380022321428571e-05 1.8 1.1380580357142856e-05 0.0 1.1387276785714285e-05 0.0
+ 1.138783482142857e-05 1.8 1.1397879464285713e-05 1.8 1.1398437499999998e-05 0.0 1.1405133928571428e-05 0.0
+ 1.1405691964285713e-05 1.8 1.1415736607142856e-05 1.8 1.1416294642857142e-05 0.0 1.142299107142857e-05 0.0
+ 1.1423549107142857e-05 1.8 1.143359375e-05 1.8 1.1434151785714285e-05 0.0 1.1440848214285714e-05 0.0
+ 1.1441406249999999e-05 1.8 1.1451450892857142e-05 1.8 1.1452008928571427e-05 0.0 1.1458705357142856e-05 0.0
+ 1.1459263392857141e-05 1.8 1.1469308035714284e-05 1.8 1.1469866071428571e-05 0.0 1.1476562499999999e-05 0.0
+ 1.1477120535714285e-05 1.8 1.1487165178571428e-05 1.8 1.1487723214285713e-05 0.0 1.1494419642857143e-05 0.0
+ 1.1494977678571428e-05 1.8 1.150502232142857e-05 1.8 1.1505580357142856e-05 0.0 1.1512276785714285e-05 0.0
+ 1.151283482142857e-05 1.8 1.1522879464285713e-05 1.8 1.15234375e-05 0.0 1.1530133928571427e-05 0.0 1.1530691964285714e-05
+ 1.8 1.1540736607142857e-05 1.8 1.1541294642857142e-05 0.0 1.1547991071428571e-05 0.0
+ 1.1548549107142856e-05 1.8 1.155859375e-05 1.8 1.1559151785714284e-05 0.0 1.1565848214285714e-05 0.0
+ 1.1566406249999999e-05 1.8 1.1576450892857142e-05 1.8 1.1577008928571428e-05 0.0 1.1583705357142856e-05 0.0
+ 1.1584263392857143e-05 1.8 1.1594308035714286e-05 1.8 1.159486607142857e-05 0.0 1.16015625e-05 0.0 1.1602120535714285e-05
+ 1.8 1.1612165178571428e-05 1.8 1.1612723214285713e-05 0.0 1.1619419642857142e-05 0.0
+ 1.1619977678571427e-05 1.8 1.163002232142857e-05 1.8 1.1630580357142857e-05 0.0 1.1637276785714285e-05 0.0
+ 1.1637834821428571e-05 1.8 1.1647879464285713e-05 1.8 1.16484375e-05 0.0 1.1655133928571427e-05 0.0 1.1655691964285714e-05
+ 1.8 1.1665736607142857e-05 1.8 1.1666294642857142e-05 0.0 1.1672991071428571e-05 0.0
+ 1.1673549107142856e-05 1.8 1.1683035714285714e-05 1.8 1.1683593749999999e-05 0.0 1.169140625e-05 0.0
+ 1.1691964285714285e-05 1.8 1.1700892857142856e-05 1.8 1.1701450892857141e-05 0.0 1.1709263392857142e-05 0.0
+ 1.1709821428571427e-05 1.8 1.1718749999999999e-05 1.8 1.1719308035714285e-05 0.0 1.1727120535714285e-05 0.0
+ 1.1727678571428571e-05 1.8 1.1736607142857143e-05 1.8 1.1737165178571428e-05 0.0 1.1744977678571427e-05 0.0
+ 1.1745535714285714e-05 1.8 1.1754464285714285e-05 1.8 1.175502232142857e-05 0.0 1.1762834821428571e-05 0.0
+ 1.1763392857142856e-05 1.8 1.1772321428571427e-05 1.8 1.1772879464285714e-05 0.0 1.1780691964285713e-05 0.0
+ 1.1781249999999998e-05 1.8 1.1790178571428571e-05 1.8 1.1790736607142856e-05 0.0 1.1798549107142856e-05 0.0
+ 1.1799107142857142e-05 1.8 1.1808035714285714e-05 1.8 1.1808593749999999e-05 0.0 1.181640625e-05 0.0
+ 1.1816964285714285e-05 1.8 1.1825892857142856e-05 1.8 1.1826450892857143e-05 0.0 1.1834263392857142e-05 0.0
+ 1.1834821428571427e-05 1.8 1.184375e-05 1.8 1.1844308035714285e-05 0.0 1.1852120535714284e-05 0.0 1.1852678571428571e-05
+ 1.8 1.1861607142857142e-05 1.8 1.1862165178571427e-05 0.0 1.1869977678571428e-05 0.0
+ 1.1870535714285713e-05 1.8 1.1879464285714285e-05 1.8 1.1880022321428571e-05 0.0 1.188783482142857e-05 0.0
+ 1.1888392857142856e-05 1.8 1.1897321428571429e-05 1.8 1.1897879464285714e-05 0.0 1.1905691964285713e-05 0.0 1.190625e-05
+ 1.8 1.1915178571428571e-05 1.8 1.1915736607142856e-05 0.0 1.1923549107142857e-05 0.0
+ 1.1924107142857142e-05 1.8 1.1933035714285713e-05 1.8 1.193359375e-05 0.0 1.194140625e-05 0.0 1.1941964285714284e-05 1.8
+ 1.1950892857142856e-05 1.8 1.1951450892857142e-05 0.0 1.1959263392857142e-05 0.0 1.1959821428571428e-05 1.8 1.196875e-05
+ 1.8 1.1969308035714285e-05 0.0 1.1977120535714286e-05 0.0 1.197767857142857e-05 1.8
+ 1.1986607142857142e-05 1.8 1.1987165178571427e-05 0.0 1.1994977678571428e-05 0.0 1.1995535714285713e-05 1.8
+ 1.2003906249999999e-05 1.8 1.2004464285714284e-05 0.0 1.2013392857142857e-05 0.0 1.2013950892857142e-05 1.8
+ 1.2021763392857141e-05 1.8 1.2022321428571428e-05 0.0 1.203125e-05 0.0 1.2031808035714284e-05 1.8 1.2039620535714285e-05
+ 1.8 1.204017857142857e-05 0.0 1.2049107142857142e-05 0.0 1.2049665178571428e-05 1.8
+ 1.2057477678571428e-05 1.8 1.2058035714285713e-05 0.0 1.2066964285714284e-05 0.0 1.206752232142857e-05 1.8
+ 1.207533482142857e-05 1.8 1.2075892857142857e-05 0.0 1.2084821428571428e-05 0.0 1.2085379464285713e-05 1.8
+ 1.2093191964285714e-05 1.8 1.209375e-05 0.0 1.210267857142857e-05 0.0 1.2103236607142857e-05 1.8 1.2111049107142856e-05
+ 1.8 1.2111607142857142e-05 0.0 1.2120535714285713e-05 0.0 1.212109375e-05 1.8 1.2128906249999999e-05
+ 1.8 1.2129464285714286e-05 0.0 1.2138392857142857e-05 0.0 1.2138950892857142e-05 1.8
+ 1.2146763392857143e-05 1.8 1.2147321428571428e-05 0.0 1.2156249999999999e-05 0.0 1.2156808035714284e-05 1.8
+ 1.2164620535714285e-05 1.8 1.216517857142857e-05 0.0 1.2174107142857141e-05 0.0 1.2174665178571428e-05 1.8
+ 1.2182477678571427e-05 1.8 1.2183035714285714e-05 0.0 1.2191964285714285e-05 0.0 1.219252232142857e-05 1.8
+ 1.220033482142857e-05 1.8 1.2200892857142857e-05 0.0 1.2209821428571428e-05 0.0 1.2210379464285713e-05 1.8
+ 1.2218191964285714e-05 1.8 1.2218749999999999e-05 0.0 1.222767857142857e-05 0.0 1.2228236607142857e-05 1.8
+ 1.2236049107142856e-05 1.8 1.2236607142857141e-05 0.0 1.2245535714285714e-05 0.0 1.2246093749999999e-05 1.8
+ 1.2253906249999998e-05 1.8 1.2254464285714285e-05 0.0 1.2263392857142856e-05 0.0 1.2263950892857141e-05 1.8
+ 1.2271763392857142e-05 1.8 1.2272321428571428e-05 0.0 1.2281249999999999e-05 0.0 1.2281808035714285e-05 1.8
+ 1.2289620535714285e-05 1.8 1.229017857142857e-05 0.0 1.2299107142857143e-05 0.0 1.2299665178571428e-05 1.8
+ 1.2307477678571427e-05 1.8 1.2308035714285714e-05 0.0 1.2316964285714285e-05 0.0 1.231752232142857e-05 1.8
+ 1.2324776785714284e-05 1.8 1.2325334821428571e-05 0.0 1.2335379464285714e-05 0.0 1.2335937499999999e-05 1.8
+ 1.2342633928571428e-05 1.8 1.2343191964285713e-05 0.0 1.2353236607142856e-05 0.0 1.2353794642857141e-05 1.8
+ 1.236049107142857e-05 1.8 1.2361049107142856e-05 0.0 1.2371093749999999e-05 0.0 1.2371651785714285e-05 1.8
+ 1.2378348214285713e-05 1.8 1.237890625e-05 0.0 1.2388950892857143e-05 0.0 1.2389508928571428e-05 1.8
+ 1.2396205357142857e-05 1.8 1.2396763392857142e-05 0.0 1.2406808035714285e-05 0.0 1.240736607142857e-05 1.8 1.24140625e-05
+ 1.8 1.2414620535714284e-05 0.0 1.2424665178571427e-05 0.0 1.2425223214285714e-05 1.8
+ 1.2431919642857142e-05 1.8 1.2432477678571428e-05 0.0 1.244252232142857e-05 0.0 1.2443080357142856e-05 1.8
+ 1.2449776785714284e-05 1.8 1.245033482142857e-05 0.0 1.2460379464285714e-05 0.0 1.2460937499999999e-05 1.8
+ 1.2467633928571428e-05 1.8 1.2468191964285713e-05 0.0 1.2478236607142856e-05 0.0 1.2478794642857141e-05 1.8
+ 1.248549107142857e-05 1.8 1.2486049107142855e-05 0.0 1.2496093749999998e-05 0.0 1.2496651785714285e-05 1.8
+ 1.2503348214285713e-05 1.8 1.250390625e-05 0.0 1.2513950892857142e-05 0.0 1.2514508928571427e-05 1.8
+ 1.2521205357142857e-05 1.8 1.2521763392857142e-05 0.0 1.2531808035714285e-05 0.0 1.253236607142857e-05 1.8
+ 1.2539062499999999e-05 1.8 1.2539620535714284e-05 0.0 1.2549665178571427e-05 0.0 1.2550223214285714e-05 1.8
+ 1.2556919642857141e-05 1.8 1.2557477678571428e-05 0.0 1.2567522321428571e-05 0.0 1.2568080357142856e-05 1.8
+ 1.2574776785714285e-05 1.8 1.257533482142857e-05 0.0 1.2585379464285713e-05 0.0 1.2585937499999998e-05 1.8
+ 1.2592633928571428e-05 1.8 1.2593191964285713e-05 0.0 1.2603236607142856e-05 0.0 1.2603794642857142e-05 1.8
+ 1.261049107142857e-05 1.8 1.2611049107142857e-05 0.0 1.262109375e-05 0.0 1.2621651785714285e-05 1.8
+ 1.2628348214285714e-05 1.8 1.2628906249999999e-05 0.0 1.2638950892857142e-05 0.0 1.2639508928571427e-05 1.8
+ 1.2646205357142856e-05 1.8 1.2646763392857141e-05 0.0 1.2656808035714284e-05 0.0 1.2657366071428571e-05 1.8
+ 1.2664062499999999e-05 1.8 1.2664620535714285e-05 0.0 1.2675223214285713e-05 0.0 1.2675781249999999e-05 1.8
+ 1.2681361607142856e-05 1.8 1.2681919642857143e-05 0.0 1.2693080357142856e-05 0.0 1.2693638392857143e-05 1.8
+ 1.269921875e-05 1.8 1.2699776785714285e-05 0.0 1.27109375e-05 0.0 1.2711495535714285e-05 1.8 1.2717075892857142e-05
+ 1.8 1.2717633928571427e-05 0.0 1.2728794642857142e-05 0.0 1.2729352678571427e-05 1.8
+ 1.2734933035714285e-05 1.8 1.2735491071428571e-05 0.0 1.2746651785714284e-05 0.0 1.2747209821428571e-05 1.8
+ 1.2752790178571427e-05 1.8 1.2753348214285714e-05 0.0 1.2764508928571428e-05 0.0 1.2765066964285714e-05 1.8
+ 1.2770647321428571e-05 1.8 1.2771205357142856e-05 0.0 1.278236607142857e-05 0.0 1.2782924107142856e-05 1.8
+ 1.2788504464285713e-05 1.8 1.2789062499999998e-05 0.0 1.2800223214285713e-05 0.0 1.280078125e-05 1.8
+ 1.2806361607142856e-05 1.8 1.2806919642857142e-05 0.0 1.2818080357142855e-05 0.0 1.2818638392857142e-05 1.8
+ 1.282421875e-05 1.8 1.2824776785714285e-05 0.0 1.28359375e-05 0.0 1.2836495535714285e-05 1.8 1.2842075892857142e-05
+ 1.8 1.2842633928571427e-05 0.0 1.2853794642857142e-05 0.0 1.2854352678571427e-05 1.8
+ 1.2859933035714284e-05 1.8 1.2860491071428571e-05 0.0 1.2871651785714284e-05 0.0 1.2872209821428571e-05 1.8
+ 1.2877790178571428e-05 1.8 1.2878348214285713e-05 0.0 1.2889508928571428e-05 0.0 1.2890066964285713e-05 1.8
+ 1.289564732142857e-05 1.8 1.2896205357142856e-05 0.0 1.290736607142857e-05 0.0 1.2907924107142855e-05 1.8
+ 1.2913504464285713e-05 1.8 1.29140625e-05 0.0 1.2925223214285713e-05 0.0 1.292578125e-05 1.8 1.2931361607142857e-05 1.8
+ 1.2931919642857142e-05 0.0 1.2943080357142857e-05 0.0 1.2943638392857142e-05 1.8 1.294921875e-05 1.8
+ 1.2949776785714284e-05 0.0 1.2960937499999999e-05 0.0 1.2961495535714284e-05 1.8 1.2967075892857142e-05 1.8
+ 1.2967633928571428e-05 0.0 1.2978794642857141e-05 0.0 1.2979352678571428e-05 1.8 1.2984933035714286e-05 1.8
+ 1.298549107142857e-05 0.0 1.2996651785714285e-05 0.0 1.299720982142857e-05 1.8 1.3002790178571428e-05 1.8
+ 1.3003348214285713e-05 0.0 1.3014508928571428e-05 0.0 1.3015066964285713e-05 1.8 1.302064732142857e-05 1.8
+ 1.3021205357142857e-05 0.0 1.303236607142857e-05 0.0 1.3032924107142857e-05 1.8 1.3038504464285713e-05 1.8 1.30390625e-05
+ 0.0 1.3050223214285714e-05 0.0 1.305078125e-05 1.8 1.3056361607142857e-05 1.8 1.3056919642857142e-05
+ 0.0 1.3068080357142856e-05 0.0 1.3068638392857141e-05 1.8 1.3074218749999999e-05 1.8
+ 1.3074776785714284e-05 0.0 1.3086495535714286e-05 0.0 1.308705357142857e-05 1.8 1.3091517857142856e-05 1.8
+ 1.3092075892857141e-05 0.0 1.3104352678571428e-05 0.0 1.3104910714285713e-05 1.8 1.3109374999999998e-05 1.8
+ 1.3109933035714285e-05 0.0 1.312220982142857e-05 0.0 1.3122767857142857e-05 1.8 1.3127232142857142e-05 1.8
+ 1.3127790178571428e-05 0.0 1.3140066964285714e-05 0.0 1.3140625e-05 1.8 1.3145089285714285e-05 1.8 1.314564732142857e-05
+ 0.0 1.3157924107142856e-05 0.0 1.3158482142857142e-05 1.8 1.3162946428571427e-05 1.8
+ 1.3163504464285714e-05 0.0 1.3175781249999999e-05 0.0 1.3176339285714286e-05 1.8 1.3180803571428571e-05 1.8
+ 1.3181361607142856e-05 0.0 1.3193638392857141e-05 0.0 1.3194196428571428e-05 1.8 1.3198660714285713e-05 1.8
+ 1.3199218749999999e-05 0.0 1.3211495535714285e-05 0.0 1.321205357142857e-05 1.8 1.3216517857142856e-05 1.8
+ 1.3217075892857143e-05 0.0 1.3229352678571427e-05 0.0 1.3229910714285713e-05 1.8 1.3234375e-05 1.8 1.3234933035714285e-05
+ 0.0 1.324720982142857e-05 0.0 1.3247767857142857e-05 1.8 1.3252232142857142e-05 1.8
+ 1.3252790178571427e-05 0.0 1.3265066964285714e-05 0.0 1.3265624999999999e-05 1.8 1.3270089285714284e-05 1.8
+ 1.3270647321428571e-05 0.0 1.3282924107142856e-05 0.0 1.3283482142857141e-05 1.8 1.3287946428571427e-05 1.8
+ 1.3288504464285714e-05 0.0 1.3300781249999998e-05 0.0 1.3301339285714285e-05 1.8 1.330580357142857e-05 1.8
+ 1.3306361607142856e-05 0.0 1.3318638392857142e-05 0.0 1.3319196428571428e-05 1.8 1.3323660714285713e-05 1.8
+ 1.332421875e-05 0.0 1.3336495535714285e-05 0.0 1.333705357142857e-05 1.8 1.3341517857142855e-05 1.8
+ 1.3342075892857142e-05 0.0 1.3354352678571427e-05 0.0 1.3354910714285714e-05 1.8 1.3359375e-05 1.8 1.3359933035714285e-05
+ 0.0 1.3372209821428571e-05 0.0 1.3372767857142856e-05 1.8 1.3377232142857142e-05 1.8
+ 1.3377790178571427e-05 0.0 1.3390066964285713e-05 0.0 1.3390624999999999e-05 1.8 1.3395089285714284e-05 1.8
+ 1.3395647321428571e-05 0.0 1.3407924107142856e-05 0.0 1.3408482142857143e-05 1.8 1.3412946428571428e-05 1.8
+ 1.3413504464285713e-05 0.0 1.342578125e-05 0.0 1.3426339285714285e-05 1.8 1.343080357142857e-05 1.8 1.3431361607142856e-05
+ 0.0 1.3443638392857142e-05 0.0 1.3444196428571427e-05 1.8 1.3448660714285713e-05 1.8 1.344921875e-05
+ 0.0 1.3461495535714284e-05 0.0 1.3462053571428571e-05 1.8 1.3466517857142857e-05 1.8
+ 1.3467075892857142e-05 0.0 1.3479352678571427e-05 0.0 1.3479910714285714e-05 1.8 1.3484374999999999e-05 1.8
+ 1.3484933035714284e-05 0.0 1.349720982142857e-05 0.0 1.3497767857142856e-05 1.8 1.3502232142857141e-05 1.8
+ 1.3502790178571428e-05 0.0 1.3515066964285713e-05 0.0 1.3515625e-05 1.8 1.3520089285714285e-05 1.8 1.352064732142857e-05
+ 0.0 1.3532924107142855e-05 0.0 1.3533482142857142e-05 1.8 1.3537946428571428e-05 1.8
+ 1.3538504464285713e-05 0.0 1.355078125e-05 0.0 1.3551339285714285e-05 1.8 1.355580357142857e-05 1.8 1.3556361607142857e-05
+ 0.0 1.3568638392857142e-05 0.0 1.3569196428571427e-05 1.8 1.3573660714285714e-05 1.8 1.357421875e-05
+ 0.0 1.3586495535714284e-05 0.0 1.3587053571428571e-05 1.8 1.3591517857142856e-05 1.8
+ 1.3592075892857142e-05 0.0 1.3604352678571428e-05 0.0 1.3604910714285713e-05 1.8 1.3609374999999999e-05 1.8
+ 1.3609933035714286e-05 0.0 1.362220982142857e-05 0.0 1.3622767857142856e-05 1.8 1.3627232142857141e-05 1.8
+ 1.3627790178571428e-05 0.0 1.3640066964285713e-05 0.0 1.3640625e-05 1.8 1.3645089285714285e-05 1.8 1.364564732142857e-05
+ 0.0 1.3657924107142857e-05 0.0 1.3658482142857142e-05 1.8 1.3662946428571427e-05 1.8
+ 1.3663504464285712e-05 0.0 1.3675781249999999e-05 0.0 1.3676339285714284e-05 1.8 1.368080357142857e-05 1.8
+ 1.3681361607142857e-05 0.0 1.3693638392857141e-05 0.0 1.3694196428571428e-05 1.8 1.3698660714285714e-05 1.8
+ 1.3699218749999999e-05 0.0 1.3711495535714285e-05 0.0 1.371205357142857e-05 1.8 1.3716517857142856e-05 1.8
+ 1.3717075892857141e-05 0.0 1.3729352678571428e-05 0.0 1.3729910714285713e-05 1.8 1.3734374999999998e-05 1.8
+ 1.3734933035714285e-05 0.0 1.374720982142857e-05 0.0 1.3747767857142857e-05 1.8 1.3752232142857142e-05 1.8
+ 1.3752790178571427e-05 0.0 1.3765066964285714e-05 0.0 1.3765625e-05 1.8 1.3770089285714285e-05 1.8 1.377064732142857e-05
+ 0.0 1.3782924107142856e-05 0.0 1.3783482142857141e-05 1.8 1.3787946428571427e-05 1.8
+ 1.3788504464285714e-05 0.0 1.3800781249999999e-05 0.0 1.3801339285714286e-05 1.8 1.3805803571428571e-05 1.8
+ 1.3806361607142856e-05 0.0 1.3818638392857141e-05 0.0 1.3819196428571428e-05 1.8 1.3823660714285713e-05 1.8
+ 1.3824218749999998e-05 0.0 1.3836495535714285e-05 0.0 1.383705357142857e-05 1.8 1.3841517857142856e-05 1.8
+ 1.3842075892857142e-05 0.0 1.3854352678571427e-05 0.0 1.3854910714285712e-05 1.8 1.3859375e-05 1.8 1.3859933035714285e-05
+ 0.0 1.387220982142857e-05 0.0 1.3872767857142857e-05 1.8 1.3877232142857142e-05 1.8
+ 1.3877790178571427e-05 0.0 1.3890066964285714e-05 0.0 1.3890624999999999e-05 1.8 1.3895089285714284e-05 1.8
+ 1.3895647321428571e-05 0.0 1.3907924107142856e-05 0.0 1.3908482142857141e-05 1.8 1.3912946428571427e-05 1.8
+ 1.3913504464285713e-05 0.0 1.3925781249999998e-05 0.0 1.3926339285714285e-05 1.8 1.393080357142857e-05 1.8
+ 1.3931361607142856e-05 0.0 1.3943638392857142e-05 0.0 1.3944196428571427e-05 1.8 1.3948660714285713e-05 1.8
+ 1.394921875e-05 0.0 1.3961495535714285e-05 0.0 1.396205357142857e-05 1.8 1.3966517857142855e-05 1.8
+ 1.3967075892857142e-05 0.0 1.3979352678571427e-05 0.0 1.3979910714285714e-05 1.8 1.3984375e-05 1.8 1.3984933035714284e-05
+ 0.0 1.3997209821428571e-05 0.0 1.3997767857142856e-05 1.8 1.4002232142857142e-05 1.8
+ 1.4002790178571427e-05 0.0 1.4015066964285713e-05 0.0 1.4015624999999998e-05 1.8 1.4020089285714284e-05 1.8
+ 1.402064732142857e-05 0.0 1.4032924107142856e-05 0.0 1.4033482142857142e-05 1.8 1.4037946428571428e-05 1.8
+ 1.4038504464285713e-05 0.0 1.405078125e-05 0.0 1.4051339285714285e-05 1.8 1.405580357142857e-05 1.8 1.4056361607142855e-05
+ 0.0 1.4068638392857142e-05 0.0 1.4069196428571427e-05 1.8 1.4073660714285713e-05 1.8 1.407421875e-05
+ 0.0 1.4086495535714284e-05 0.0 1.4087053571428571e-05 1.8 1.4091517857142857e-05 1.8
+ 1.4092075892857142e-05 0.0 1.4104352678571427e-05 0.0 1.4104910714285713e-05 1.8 1.4109374999999999e-05 1.8
+ 1.4109933035714284e-05 0.0 1.412220982142857e-05 0.0 1.4122767857142856e-05 1.8 1.4127232142857141e-05 1.8
+ 1.4127790178571428e-05 0.0 1.4140066964285713e-05 0.0 1.4140625e-05 1.8 1.4145089285714285e-05 1.8 1.414564732142857e-05
+ 0.0 1.4157924107142855e-05 0.0 1.4158482142857142e-05 1.8 1.4162946428571428e-05 1.8
+ 1.4163504464285713e-05 0.0 1.417578125e-05 0.0 1.4176339285714284e-05 1.8 1.418080357142857e-05 1.8 1.4181361607142857e-05
+ 0.0 1.4193638392857142e-05 0.0 1.4194196428571427e-05 1.8 1.4198660714285714e-05 1.8
+ 1.4199218749999999e-05 0.0 1.4211495535714284e-05 0.0 1.421205357142857e-05 1.8 1.4216517857142856e-05 1.8
+ 1.4217075892857141e-05 0.0 1.4229352678571428e-05 0.0 1.4229910714285713e-05 1.8 1.4234374999999999e-05 1.8
+ 1.4234933035714285e-05 0.0 1.424720982142857e-05 0.0 1.4247767857142855e-05 1.8 1.4252232142857141e-05 1.8
+ 1.4252790178571428e-05 0.0 1.4265066964285713e-05 0.0 1.4265625e-05 1.8 1.4270089285714285e-05 1.8 1.427064732142857e-05
+ 0.0 1.4282924107142857e-05 0.0 1.4283482142857142e-05 1.8 1.4287946428571427e-05 1.8
+ 1.4288504464285712e-05 0.0 1.4300781249999999e-05 0.0 1.4301339285714284e-05 1.8 1.430580357142857e-05 1.8
+ 1.4306361607142856e-05 0.0 1.4318638392857141e-05 0.0 1.4319196428571428e-05 1.8 1.4323660714285714e-05 1.8
+ 1.4324218749999999e-05 0.0 1.4336495535714285e-05 0.0 1.433705357142857e-05 1.8 1.4341517857142856e-05 1.8
+ 1.4342075892857141e-05 0.0 1.4354352678571428e-05 0.0 1.4354910714285713e-05 1.8 1.4359374999999998e-05 1.8
+ 1.4359933035714285e-05 0.0 1.437220982142857e-05 0.0 1.4372767857142857e-05 1.8 1.4377232142857142e-05 1.8
+ 1.4377790178571427e-05 0.0 1.4390066964285714e-05 0.0 1.4390624999999999e-05 1.8 1.4395089285714285e-05 1.8
+ 1.439564732142857e-05 0.0 1.4407924107142856e-05 0.0 1.4408482142857141e-05 1.8 1.4412946428571427e-05 1.8
+ 1.4413504464285714e-05 0.0 1.4425781249999999e-05 0.0 1.4426339285714285e-05 1.8 1.4430803571428571e-05 1.8
+ 1.4431361607142856e-05 0.0 1.4443638392857141e-05 0.0 1.4444196428571428e-05 1.8 1.4448660714285713e-05 1.8
+ 1.4449218749999998e-05 0.0 1.4461495535714285e-05 0.0 1.446205357142857e-05 1.8 1.4466517857142856e-05 1.8
+ 1.4467075892857142e-05 0.0 1.4479352678571427e-05 0.0 1.4479910714285712e-05 1.8 1.4484375e-05 1.8 1.4484933035714285e-05
+ 0.0 1.449720982142857e-05 0.0 1.4497767857142856e-05 1.8 1.4502232142857142e-05 1.8
+ 1.4502790178571427e-05 0.0 1.4515066964285714e-05 0.0 1.4515624999999999e-05 1.8 1.4520089285714284e-05 1.8
+ 1.4520647321428571e-05 0.0 1.4532924107142856e-05 0.0 1.4533482142857141e-05 1.8 1.4537946428571428e-05 1.8
+ 1.4538504464285713e-05 0.0 1.4550781249999998e-05 0.0 1.4551339285714285e-05 1.8 1.455580357142857e-05 1.8
+ 1.4556361607142856e-05 0.0 1.4568638392857142e-05 0.0 1.4569196428571427e-05 1.8 1.4573660714285713e-05 1.8
+ 1.457421875e-05 0.0 1.4586495535714285e-05 0.0 1.458705357142857e-05 1.8 1.4591517857142855e-05 1.8
+ 1.4592075892857142e-05 0.0 1.4604352678571427e-05 0.0 1.4604910714285714e-05 1.8 1.4609375e-05 1.8 1.4609933035714284e-05
+ 0.0 1.4622209821428571e-05 0.0 1.4622767857142856e-05 1.8 1.4627232142857142e-05 1.8
+ 1.4627790178571427e-05 0.0 1.4640066964285713e-05 0.0 1.4640624999999998e-05 1.8 1.4645089285714284e-05 1.8
+ 1.464564732142857e-05 0.0 1.4657924107142856e-05 0.0 1.4658482142857142e-05 1.8 1.4662946428571428e-05 1.8
+ 1.4663504464285713e-05 0.0 1.467578125e-05 0.0 1.4676339285714285e-05 1.8 1.468080357142857e-05 1.8 1.4681361607142855e-05
+ 0.0 1.4693638392857142e-05 0.0 1.4694196428571427e-05 1.8 1.4698660714285713e-05 1.8 1.469921875e-05
+ 0.0 1.4711495535714284e-05 0.0 1.4712053571428571e-05 1.8 1.4716517857142857e-05 1.8
+ 1.4717075892857142e-05 0.0 1.4729352678571427e-05 0.0 1.4729910714285713e-05 1.8 1.4734374999999999e-05 1.8
+ 1.4734933035714284e-05 0.0 1.474720982142857e-05 0.0 1.4747767857142856e-05 1.8 1.4752232142857141e-05 1.8
+ 1.4752790178571428e-05 0.0 1.4765066964285713e-05 0.0 1.4765625e-05 1.8 1.4770089285714285e-05 1.8 1.477064732142857e-05
+ 0.0 1.4782924107142855e-05 0.0 1.4783482142857142e-05 1.8 1.4787946428571428e-05 1.8
+ 1.4788504464285713e-05 0.0 1.480078125e-05 0.0 1.4801339285714284e-05 1.8 1.480580357142857e-05 1.8 1.4806361607142857e-05
+ 0.0 1.4818638392857142e-05 0.0 1.4819196428571427e-05 1.8 1.4823660714285714e-05 1.8
+ 1.4824218749999999e-05 0.0 1.4836495535714284e-05 0.0 1.483705357142857e-05 1.8 1.4841517857142856e-05 1.8
+ 1.4842075892857141e-05 0.0 1.4854352678571428e-05 0.0 1.4854910714285713e-05 1.8 1.4859374999999999e-05 1.8
+ 1.4859933035714285e-05 0.0 1.487220982142857e-05 0.0 1.4872767857142855e-05 1.8 1.4877232142857141e-05 1.8
+ 1.4877790178571428e-05 0.0 1.4890066964285713e-05 0.0 1.4890625e-05 1.8 1.4895089285714285e-05 1.8 1.489564732142857e-05
+ 0.0 1.4907924107142857e-05 0.0 1.4908482142857142e-05 1.8 1.4912946428571427e-05 1.8
+ 1.4913504464285712e-05 0.0 1.4925223214285714e-05 0.0 1.4925781249999999e-05 1.8 1.4931361607142856e-05 1.8
+ 1.4931919642857141e-05 0.0 1.4943080357142856e-05 0.0 1.4943638392857141e-05 1.8 1.4949218749999999e-05 1.8
+ 1.4949776785714285e-05 0.0 1.4960937499999999e-05 0.0 1.4961495535714285e-05 1.8 1.4967075892857141e-05 1.8
+ 1.4967633928571428e-05 0.0 1.4978794642857143e-05 0.0 1.4979352678571428e-05 1.8 1.4984933035714285e-05 1.8
+ 1.498549107142857e-05 0.0 1.4996651785714285e-05 0.0 1.499720982142857e-05 1.8 1.5002790178571427e-05 1.8
+ 1.5003348214285712e-05 0.0 1.5014508928571427e-05 0.0 1.5015066964285714e-05 1.8 1.502064732142857e-05 1.8
+ 1.5021205357142856e-05 0.0 1.503236607142857e-05 0.0 1.5032924107142856e-05 1.8 1.5038504464285714e-05 1.8
+ 1.5039062499999999e-05 0.0 1.5050223214285714e-05 0.0 1.5050781249999999e-05 1.8 1.5056361607142856e-05 1.8
+ 1.5056919642857141e-05 0.0 1.5068080357142856e-05 0.0 1.5068638392857141e-05 1.8 1.5074218749999998e-05 1.8
+ 1.5074776785714285e-05 0.0 1.5085937499999998e-05 0.0 1.5086495535714285e-05 1.8 1.5092075892857142e-05 1.8
+ 1.5092633928571427e-05 0.0 1.5103794642857142e-05 0.0 1.5104352678571427e-05 1.8 1.5109933035714285e-05 1.8
+ 1.511049107142857e-05 0.0 1.5121651785714285e-05 0.0 1.512220982142857e-05 1.8 1.5127790178571427e-05 1.8
+ 1.5128348214285714e-05 0.0 1.5139508928571427e-05 0.0 1.5140066964285714e-05 1.8 1.5145647321428571e-05 1.8
+ 1.5146205357142856e-05 0.0 1.5157366071428571e-05 0.0 1.5157924107142856e-05 1.8 1.5163504464285713e-05 1.8
+ 1.5164062499999998e-05 0.0 1.5175223214285713e-05 0.0 1.5175781249999998e-05 1.8 1.5181361607142856e-05 1.8
+ 1.5181919642857142e-05 0.0 1.5193080357142856e-05 0.0 1.5193638392857142e-05 1.8 1.519921875e-05 1.8
+ 1.5199776785714285e-05 0.0 1.52109375e-05 0.0 1.5211495535714285e-05 1.8 1.5217075892857142e-05 1.8 1.5217633928571427e-05
+ 0.0 1.5228794642857142e-05 0.0 1.5229352678571427e-05 1.8 1.5234933035714284e-05 1.8
+ 1.5235491071428571e-05 0.0 1.5246651785714284e-05 0.0 1.5247209821428571e-05 1.8 1.5252790178571427e-05 1.8
+ 1.5253348214285713e-05 0.0 1.5264508928571427e-05 0.0 1.5265066964285713e-05 1.8 1.527064732142857e-05 1.8
+ 1.5271205357142857e-05 0.0 1.528236607142857e-05 0.0 1.5282924107142856e-05 1.8 1.5288504464285713e-05 1.8 1.52890625e-05
+ 0.0 1.5300223214285715e-05 0.0 1.5300781249999998e-05 1.8 1.5306361607142855e-05 1.8
+ 1.5306919642857142e-05 0.0 1.5318080357142857e-05 0.0 1.531863839285714e-05 1.8 1.5324218749999998e-05 1.8
+ 1.5324776785714284e-05 0.0 1.5335379464285712e-05 0.0 1.53359375e-05 1.8 1.5342633928571427e-05 1.8 1.5343191964285714e-05
+ 0.0 1.5353236607142855e-05 0.0 1.535379464285714e-05 1.8 1.536049107142857e-05 1.8
+ 1.5361049107142856e-05 0.0 1.537109375e-05 0.0 1.5371651785714284e-05 1.8 1.5378348214285715e-05 1.8
+ 1.5378906249999998e-05 0.0 1.5388950892857143e-05 0.0 1.5389508928571426e-05 1.8 1.5396205357142857e-05 1.8
+ 1.539676339285714e-05 0.0 1.5406808035714285e-05 0.0 1.5407366071428572e-05 1.8 1.54140625e-05 1.8 1.5414620535714286e-05
+ 0.0 1.5424665178571427e-05 0.0 1.5425223214285714e-05 1.8 1.5431919642857142e-05 1.8
+ 1.543247767857143e-05 0.0 1.544252232142857e-05 0.0 1.5443080357142857e-05 1.8 1.5449776785714284e-05 1.8
+ 1.545033482142857e-05 0.0 1.5460379464285712e-05 0.0 1.54609375e-05 1.8 1.5467633928571426e-05 1.8 1.5468191964285713e-05
+ 0.0 1.5478236607142854e-05 0.0 1.547879464285714e-05 1.8 1.548549107142857e-05 1.8
+ 1.5486049107142855e-05 0.0 1.549609375e-05 0.0 1.5496651785714284e-05 1.8 1.5503348214285714e-05 1.8
+ 1.5503906249999998e-05 0.0 1.5513950892857142e-05 0.0 1.5514508928571426e-05 1.8 1.5521205357142857e-05 1.8
+ 1.552176339285714e-05 0.0 1.5531808035714285e-05 0.0 1.553236607142857e-05 1.8 1.55390625e-05 1.8 1.5539620535714286e-05
+ 0.0 1.5549665178571427e-05 0.0 1.5550223214285714e-05 1.8 1.555691964285714e-05 1.8
+ 1.5557477678571428e-05 0.0 1.556752232142857e-05 0.0 1.5568080357142856e-05 1.8 1.5574776785714284e-05 1.8
+ 1.557533482142857e-05 0.0 1.5585379464285712e-05 0.0 1.55859375e-05 1.8 1.5592633928571426e-05 1.8 1.5593191964285713e-05
+ 0.0 1.5603236607142857e-05 0.0 1.560379464285714e-05 1.8 1.5610491071428572e-05 1.8
+ 1.5611049107142855e-05 0.0 1.562109375e-05 0.0 1.5621651785714283e-05 1.8 1.5628348214285714e-05 1.8
+ 1.5628906249999997e-05 0.0 1.5638950892857142e-05 0.0 1.563950892857143e-05 1.8 1.5646205357142856e-05 1.8
+ 1.5646763392857143e-05 0.0 1.5656808035714284e-05 0.0 1.565736607142857e-05 1.8 1.56640625e-05 1.8 1.5664620535714285e-05
+ 0.0 1.5674665178571427e-05 0.0 1.5675223214285714e-05 1.8 1.5682477678571428e-05 1.8
+ 1.5683035714285715e-05 0.0 1.5691964285714286e-05 0.0 1.569252232142857e-05 1.8 1.570033482142857e-05 1.8
+ 1.5700892857142857e-05 0.0 1.5709821428571428e-05 0.0 1.5710379464285715e-05 1.8 1.5718191964285712e-05 1.8 1.571875e-05
+ 0.0 1.572767857142857e-05 0.0 1.5728236607142857e-05 1.8 1.5736049107142855e-05 1.8
+ 1.573660714285714e-05 0.0 1.5745535714285713e-05 0.0 1.574609375e-05 1.8 1.575390625e-05 1.8 1.5754464285714284e-05 0.0
+ 1.5763392857142855e-05 0.0 1.5763950892857142e-05 1.8 1.5771763392857143e-05 1.8 1.5772321428571426e-05 0.0
+ 1.5781249999999997e-05 0.0 1.5781808035714284e-05 1.8 1.5789620535714285e-05 1.8 1.5790178571428572e-05 0.0
+ 1.5799107142857143e-05 0.0 1.5799665178571426e-05 1.8 1.5807477678571427e-05 1.8 1.5808035714285714e-05 0.0
+ 1.5816964285714285e-05 0.0 1.581752232142857e-05 1.8 1.582533482142857e-05 1.8 1.5825892857142857e-05 0.0
+ 1.5834821428571428e-05 0.0 1.5835379464285714e-05 1.8 1.5843191964285712e-05 1.8 1.584375e-05 0.0 1.585267857142857e-05
+ 0.0 1.5853236607142857e-05 1.8 1.5861049107142854e-05 1.8 1.586160714285714e-05 0.0
+ 1.5870535714285712e-05 0.0 1.587109375e-05 1.8 1.587890625e-05 1.8 1.5879464285714284e-05 0.0 1.5888392857142855e-05 0.0
+ 1.588895089285714e-05 1.8 1.5896763392857142e-05 1.8 1.5897321428571426e-05 0.0 1.590625e-05 0.0 1.5906808035714284e-05
+ 1.8 1.5914620535714285e-05 1.8 1.591517857142857e-05 0.0 1.5924107142857143e-05 0.0
+ 1.5924665178571426e-05 1.8 1.5932477678571427e-05 1.8 1.5933035714285714e-05 0.0 1.5941964285714285e-05 0.0
+ 1.5942522321428572e-05 1.8 1.595033482142857e-05 1.8 1.5950892857142856e-05 0.0 1.5959821428571427e-05 0.0
+ 1.5960379464285714e-05 1.8 1.5968191964285712e-05 1.8 1.596875e-05 0.0 1.597767857142857e-05 0.0 1.5978236607142856e-05
+ 1.8 1.5986049107142857e-05 1.8 1.598660714285714e-05 0.0 1.5995535714285712e-05 0.0 1.599609375e-05 1.8
+ 1.6004464285714283e-05 1.8 1.600502232142857e-05 0.0 1.601283482142857e-05 0.0 1.6013392857142854e-05 1.8
+ 1.602232142857143e-05 1.8 1.6022879464285712e-05 0.0 1.6030691964285713e-05 0.0 1.603125e-05 1.8 1.604017857142857e-05
+ 1.8 1.6040736607142855e-05 0.0 1.6048549107142856e-05 0.0 1.6049107142857142e-05 1.8
+ 1.6058035714285714e-05 1.8 1.605859375e-05 0.0 1.6066406249999998e-05 0.0 1.6066964285714285e-05 1.8
+ 1.6075892857142856e-05 1.8 1.6076450892857143e-05 0.0 1.608426339285714e-05 0.0 1.6084821428571427e-05 1.8
+ 1.6093749999999998e-05 1.8 1.6094308035714285e-05 0.0 1.6102120535714286e-05 0.0 1.610267857142857e-05 1.8
+ 1.611160714285714e-05 1.8 1.6112165178571427e-05 0.0 1.6119977678571428e-05 0.0 1.612053571428571e-05 1.8
+ 1.6129464285714286e-05 1.8 1.613002232142857e-05 0.0 1.613783482142857e-05 0.0 1.6138392857142857e-05 1.8
+ 1.614732142857143e-05 1.8 1.6147879464285712e-05 0.0 1.6155691964285713e-05 0.0 1.615625e-05 1.8 1.616517857142857e-05
+ 1.8 1.6165736607142858e-05 0.0 1.6173549107142855e-05 0.0 1.6174107142857142e-05 1.8
+ 1.6183035714285713e-05 1.8 1.618359375e-05 0.0 1.6191406249999998e-05 0.0 1.6191964285714284e-05 1.8
+ 1.6200892857142855e-05 1.8 1.6201450892857142e-05 0.0 1.6209263392857143e-05 0.0 1.6209821428571427e-05 1.8
+ 1.6218749999999998e-05 1.8 1.6219308035714285e-05 0.0 1.6227120535714286e-05 0.0 1.622767857142857e-05 1.8
+ 1.623660714285714e-05 1.8 1.6237165178571427e-05 0.0 1.6244977678571428e-05 0.0 1.6245535714285715e-05 1.8
+ 1.6254464285714286e-05 1.8 1.625502232142857e-05 0.0 1.626283482142857e-05 0.0 1.6263392857142857e-05 1.8
+ 1.6272321428571428e-05 1.8 1.627287946428571e-05 0.0 1.6280691964285713e-05 0.0 1.628125e-05 1.8 1.629017857142857e-05 1.8
+ 1.6290736607142857e-05 0.0 1.6298549107142855e-05 0.0 1.629910714285714e-05 1.8 1.6308035714285713e-05 1.8 1.630859375e-05
+ 0.0 1.6316406249999997e-05 0.0 1.6316964285714284e-05 1.8 1.6326450892857142e-05 1.8
+ 1.632700892857143e-05 0.0 1.6333705357142856e-05 0.0 1.6334263392857143e-05 1.8 1.6344308035714284e-05 1.8
+ 1.634486607142857e-05 0.0 1.63515625e-05 0.0 1.6352120535714285e-05 1.8 1.6362165178571427e-05 1.8 1.6362723214285713e-05
+ 0.0 1.636941964285714e-05 0.0 1.6369977678571428e-05 1.8 1.638002232142857e-05 1.8
+ 1.6380580357142856e-05 0.0 1.6387276785714283e-05 0.0 1.638783482142857e-05 1.8 1.6397879464285715e-05 1.8
+ 1.6398437499999998e-05 0.0 1.640513392857143e-05 0.0 1.6405691964285712e-05 1.8 1.6415736607142857e-05 1.8
+ 1.641629464285714e-05 0.0 1.642299107142857e-05 0.0 1.6423549107142855e-05 1.8 1.643359375e-05 1.8 1.6434151785714286e-05
+ 0.0 1.6440848214285714e-05 0.0 1.644140625e-05 1.8 1.645145089285714e-05 1.8 1.645200892857143e-05 0.0
+ 1.6458705357142856e-05 0.0 1.6459263392857143e-05 1.8 1.6469308035714284e-05 1.8 1.646986607142857e-05 0.0
+ 1.6476562499999998e-05 0.0 1.6477120535714285e-05 1.8 1.6487165178571426e-05 1.8 1.6487723214285713e-05 0.0
+ 1.649441964285714e-05 0.0 1.6494977678571427e-05 1.8 1.6505022321428572e-05 1.8 1.6505580357142855e-05 0.0
+ 1.6512276785714286e-05 0.0 1.651283482142857e-05 1.8 1.6522879464285714e-05 1.8 1.6523437499999998e-05 0.0
+ 1.653013392857143e-05 0.0 1.6530691964285712e-05 1.8 1.6540736607142857e-05 1.8 1.6541294642857143e-05 0.0
+ 1.654799107142857e-05 0.0 1.6548549107142858e-05 1.8 1.655859375e-05 1.8 1.6559151785714286e-05 0.0
+ 1.6565848214285713e-05 0.0 1.656640625e-05 1.8 1.657645089285714e-05 1.8 1.6577008928571428e-05 0.0 1.6583705357142855e-05
+ 0.0 1.6584263392857142e-05 1.8 1.6594308035714284e-05 1.8 1.659486607142857e-05 0.0
+ 1.6601562499999998e-05 0.0 1.6602120535714285e-05 1.8 1.6612165178571426e-05 1.8 1.6612723214285713e-05 0.0
+ 1.661941964285714e-05 0.0 1.6619977678571427e-05 1.8 1.663002232142857e-05 1.8 1.6630580357142855e-05 0.0
+ 1.6637276785714286e-05 0.0 1.663783482142857e-05 1.8 1.6647879464285714e-05 1.8 1.6648437499999997e-05 0.0
+ 1.6655133928571428e-05 0.0 1.665569196428571e-05 1.8 1.6665736607142856e-05 1.8 1.6666294642857143e-05 0.0
+ 1.6672433035714284e-05 0.0 1.667299107142857e-05 1.8 1.6684151785714285e-05 1.8 1.668470982142857e-05 0.0
+ 1.6690290178571426e-05 0.0 1.6690848214285713e-05 1.8 1.6702008928571428e-05 1.8 1.6702566964285714e-05 0.0
+ 1.6708147321428572e-05 0.0 1.6708705357142855e-05 1.8 1.671986607142857e-05 1.8 1.6720424107142857e-05 0.0
+ 1.6726004464285714e-05 0.0 1.6726562499999997e-05 1.8 1.6737723214285712e-05 1.8 1.673828125e-05 0.0
+ 1.6743861607142856e-05 0.0 1.6744419642857143e-05 1.8 1.6755580357142855e-05 1.8 1.675613839285714e-05 0.0 1.676171875e-05
+ 0.0 1.6762276785714285e-05 1.8 1.67734375e-05 1.8 1.6773995535714284e-05 0.0 1.677957589285714e-05 0.0
+ 1.6780133928571428e-05 1.8 1.6791294642857143e-05 1.8 1.6791852678571426e-05 0.0 1.6797433035714283e-05 0.0
+ 1.679799107142857e-05 1.8 1.6809151785714285e-05 1.8 1.680970982142857e-05 0.0 1.6815290178571426e-05 0.0
+ 1.6815848214285712e-05 1.8 1.6827008928571427e-05 1.8 1.6827566964285714e-05 0.0 1.683314732142857e-05 0.0
+ 1.6833705357142855e-05 1.8 1.684486607142857e-05 1.8 1.6845424107142856e-05 0.0 1.6851004464285714e-05 0.0
+ 1.6851562499999997e-05 1.8 1.6862723214285712e-05 1.8 1.686328125e-05 0.0 1.6868861607142856e-05 0.0
+ 1.6869419642857143e-05 1.8 1.6880580357142858e-05 1.8 1.688113839285714e-05 0.0 1.688671875e-05 0.0 1.6887276785714285e-05
+ 1.8 1.68984375e-05 1.8 1.6898995535714283e-05 0.0 1.690457589285714e-05 0.0 1.6905133928571427e-05 1.8
+ 1.6916294642857142e-05 1.8 1.691685267857143e-05 0.0 1.6922433035714283e-05 0.0 1.692299107142857e-05 1.8
+ 1.6934151785714285e-05 1.8 1.693470982142857e-05 0.0 1.694029017857143e-05 0.0 1.6940848214285712e-05 1.8
+ 1.6952008928571427e-05 1.8 1.6952566964285714e-05 0.0 1.695814732142857e-05 0.0 1.6958705357142854e-05 1.8
+ 1.696986607142857e-05 1.8 1.6970424107142856e-05 0.0 1.6976004464285713e-05 0.0 1.69765625e-05 1.8 1.698772321428571e-05
+ 1.8 1.698828125e-05 0.0 1.6993861607142856e-05 0.0 1.6994419642857142e-05 1.8 1.7005580357142857e-05
+ 1.8 1.700613839285714e-05 0.0 1.7011718749999998e-05 0.0 1.7012276785714285e-05 1.8 1.70234375e-05 1.8
+ 1.7023995535714283e-05 0.0 1.702957589285714e-05 0.0 1.7030133928571427e-05 1.8 1.7041294642857142e-05 1.8
+ 1.704185267857143e-05 0.0 1.7047433035714286e-05 0.0 1.704799107142857e-05 1.8 1.7059151785714284e-05 1.8
+ 1.705970982142857e-05 0.0 1.706529017857143e-05 0.0 1.7065848214285712e-05 1.8 1.7077008928571427e-05 1.8
+ 1.7077566964285713e-05 0.0 1.7082589285714284e-05 0.0 1.708314732142857e-05 1.8 1.7095424107142856e-05 1.8
+ 1.7095982142857142e-05 0.0 1.7100446428571426e-05 0.0 1.7101004464285713e-05 1.8 1.7113281249999998e-05 1.8
+ 1.7113839285714285e-05 0.0 1.711830357142857e-05 0.0 1.7118861607142855e-05 1.8 1.713113839285714e-05 1.8
+ 1.7131696428571427e-05 0.0 1.7136160714285714e-05 0.0 1.7136718749999998e-05 1.8 1.7148995535714286e-05 1.8
+ 1.714955357142857e-05 0.0 1.7154017857142857e-05 0.0 1.715457589285714e-05 1.8 1.716685267857143e-05 1.8
+ 1.716741071428571e-05 0.0 1.7171875e-05 0.0 1.7172433035714286e-05 1.8 1.718470982142857e-05 1.8 1.7185267857142857e-05
+ 0.0 1.718973214285714e-05 0.0 1.7190290178571428e-05 1.8 1.7202566964285713e-05 1.8 1.7203125e-05 0.0
+ 1.7207589285714284e-05 0.0 1.720814732142857e-05 1.8 1.7220424107142855e-05 1.8 1.7220982142857142e-05 0.0
+ 1.7225446428571426e-05 0.0 1.7226004464285713e-05 1.8 1.7238281249999998e-05 1.8 1.7238839285714284e-05 0.0
+ 1.724330357142857e-05 0.0 1.7243861607142855e-05 1.8 1.725613839285714e-05 1.8 1.7256696428571427e-05 0.0
+ 1.7261160714285714e-05 0.0 1.7261718749999997e-05 1.8 1.7273995535714286e-05 1.8 1.727455357142857e-05 0.0
+ 1.7279017857142856e-05 0.0 1.7279575892857143e-05 1.8 1.7291852678571428e-05 1.8 1.7292410714285715e-05 0.0 1.7296875e-05
+ 0.0 1.7297433035714285e-05 1.8 1.730970982142857e-05 1.8 1.7310267857142857e-05 0.0
+ 1.731473214285714e-05 0.0 1.7315290178571428e-05 1.8 1.7327566964285713e-05 1.8 1.7328125e-05 0.0 1.7332589285714283e-05
+ 0.0 1.733314732142857e-05 1.8 1.7345424107142855e-05 1.8 1.7345982142857142e-05 0.0
+ 1.735044642857143e-05 0.0 1.7351004464285712e-05 1.8 1.7363281249999997e-05 1.8 1.7363839285714284e-05 0.0
+ 1.736830357142857e-05 0.0 1.7368861607142855e-05 1.8 1.7381138392857143e-05 1.8 1.7381696428571426e-05 0.0
+ 1.7386160714285714e-05 0.0 1.738671875e-05 1.8 1.7398995535714285e-05 1.8 1.739955357142857e-05 0.0 1.7404017857142856e-05
+ 0.0 1.7404575892857143e-05 1.8 1.7416852678571428e-05 1.8 1.7417410714285714e-05 0.0
+ 1.7421874999999998e-05 0.0 1.7422433035714285e-05 1.8 1.743470982142857e-05 1.8 1.7435267857142857e-05 0.0
+ 1.743973214285714e-05 0.0 1.7440290178571427e-05 1.8 1.7452566964285712e-05 1.8 1.7453125e-05 0.0 1.7457589285714283e-05
+ 0.0 1.745814732142857e-05 1.8 1.7470424107142855e-05 1.8 1.747098214285714e-05 0.0
+ 1.747544642857143e-05 0.0 1.7476004464285712e-05 1.8 1.748828125e-05 1.8 1.7488839285714284e-05 0.0 1.749330357142857e-05
+ 0.0 1.7493861607142854e-05 1.8 1.7506138392857143e-05 1.8 1.7506696428571426e-05 0.0
+ 1.7511160714285713e-05 0.0 1.751171875e-05 1.8 1.7523995535714285e-05 1.8 1.7524553571428572e-05 0.0
+ 1.7529017857142856e-05 0.0 1.7529575892857142e-05 1.8 1.7541852678571427e-05 1.8 1.7542410714285714e-05 0.0
+ 1.7546874999999998e-05 0.0 1.7547433035714285e-05 1.8 1.755970982142857e-05 1.8 1.7560267857142856e-05 0.0
+ 1.756473214285714e-05 0.0 1.7565290178571427e-05 1.8 1.7577566964285712e-05 1.8 1.7578125e-05 0.0 1.7582589285714286e-05
+ 0.0 1.758314732142857e-05 1.8 1.7595424107142854e-05 1.8 1.759598214285714e-05 0.0
+ 1.7600446428571428e-05 0.0 1.760100446428571e-05 1.8 1.761328125e-05 1.8 1.7613839285714283e-05 0.0 1.761830357142857e-05
+ 0.0 1.7618861607142857e-05 1.8 1.7631138392857142e-05 1.8 1.7631696428571426e-05 0.0
+ 1.7636160714285713e-05 0.0 1.763671875e-05 1.8 1.7648995535714285e-05 1.8 1.764955357142857e-05 0.0 1.7654017857142855e-05
+ 0.0 1.7654575892857142e-05 1.8 1.7666852678571427e-05 1.8 1.7667410714285714e-05 0.0
+ 1.7671874999999998e-05 0.0 1.7672433035714284e-05 1.8 1.768470982142857e-05 1.8 1.7685267857142856e-05 0.0
+ 1.7689732142857143e-05 0.0 1.7690290178571427e-05 1.8 1.770256696428571e-05 1.8 1.7703125e-05 0.0 1.7707589285714286e-05
+ 0.0 1.770814732142857e-05 1.8 1.7720424107142857e-05 1.8 1.772098214285714e-05 0.0
+ 1.7725446428571428e-05 0.0 1.7726004464285715e-05 1.8 1.773828125e-05 1.8 1.7738839285714283e-05 0.0 1.774330357142857e-05
+ 0.0 1.7743861607142857e-05 1.8 1.7756138392857142e-05 1.8 1.775669642857143e-05 0.0
+ 1.7761160714285713e-05 0.0 1.776171875e-05 1.8 1.7773995535714284e-05 1.8 1.777455357142857e-05 0.0 1.7779017857142855e-05
+ 0.0 1.777957589285714e-05 1.8 1.7791852678571427e-05 1.8 1.7792410714285713e-05 0.0
+ 1.7796874999999997e-05 0.0 1.7797433035714284e-05 1.8 1.780970982142857e-05 1.8 1.7810267857142856e-05 0.0
+ 1.7814732142857143e-05 0.0 1.7815290178571426e-05 1.8 1.7827566964285715e-05 1.8 1.7828124999999998e-05 0.0
+ 1.7832589285714285e-05 0.0 1.783314732142857e-05 1.8 1.7845424107142857e-05 1.8 1.784598214285714e-05 0.0
+ 1.7850446428571428e-05 0.0 1.7851004464285714e-05 1.8 1.786328125e-05 1.8 1.7863839285714286e-05 0.0 1.786830357142857e-05
+ 0.0 1.7868861607142857e-05 1.8 1.788113839285714e-05 1.8 1.788169642857143e-05 0.0
+ 1.7886160714285712e-05 0.0 1.788671875e-05 1.8 1.7898995535714284e-05 1.8 1.789955357142857e-05 0.0 1.7904017857142855e-05
+ 0.0 1.790457589285714e-05 1.8 1.7916852678571426e-05 1.8 1.7917410714285713e-05 0.0 1.7921875e-05 0.0
+ 1.7922433035714284e-05 1.8 1.793470982142857e-05 1.8 1.7935267857142855e-05 0.0 1.7939732142857143e-05 0.0
+ 1.7940290178571426e-05 1.8 1.7952566964285714e-05 1.8 1.7953124999999998e-05 0.0 1.7957589285714285e-05 0.0
+ 1.795814732142857e-05 1.8 1.7970424107142857e-05 1.8 1.797098214285714e-05 0.0 1.7975446428571427e-05 0.0
+ 1.7976004464285714e-05 1.8 1.798828125e-05 1.8 1.7988839285714286e-05 0.0 1.799330357142857e-05 0.0 1.7993861607142856e-05
+ 1.8 1.800613839285714e-05 1.8 1.8006696428571428e-05 0.0 1.8011160714285712e-05 0.0 1.801171875e-05 1.8
+ 1.8023995535714284e-05 1.8 1.802455357142857e-05 0.0 1.8029017857142854e-05 0.0 1.802957589285714e-05 1.8
+ 1.8041852678571426e-05 1.8 1.8042410714285713e-05 0.0 1.8046875e-05 0.0 1.8047433035714283e-05 1.8 1.805970982142857e-05
+ 1.8 1.8060267857142855e-05 0.0 1.8064732142857142e-05 0.0 1.8065290178571426e-05 1.8
+ 1.8077566964285714e-05 1.8 1.8078124999999997e-05 0.0 1.8082589285714285e-05 0.0 1.808314732142857e-05 1.8
+ 1.8095424107142856e-05 1.8 1.8095982142857143e-05 0.0 1.8100446428571427e-05 0.0 1.8101004464285714e-05 1.8
+ 1.811328125e-05 1.8 1.8113839285714285e-05 0.0 1.811830357142857e-05 0.0 1.8118861607142856e-05 1.8
+ 1.813113839285714e-05 1.8 1.8131696428571428e-05 0.0 1.813616071428571e-05 0.0 1.8136718749999998e-05 1.8
+ 1.8148995535714283e-05 1.8 1.814955357142857e-05 0.0 1.8154017857142857e-05 0.0 1.815457589285714e-05 1.8
+ 1.816685267857143e-05 1.8 1.8167410714285712e-05 0.0 1.8171875e-05 0.0 1.8172433035714283e-05 1.8 1.818470982142857e-05
+ 1.8 1.8185267857142855e-05 0.0 1.8189732142857142e-05 0.0 1.819029017857143e-05 1.8
+ 1.8202566964285714e-05 1.8 1.8203125e-05 0.0 1.8207589285714284e-05 0.0 1.820814732142857e-05 1.8 1.8220424107142856e-05
+ 1.8 1.8220982142857143e-05 0.0 1.8225446428571427e-05 0.0 1.8226004464285713e-05 1.8
+ 1.8238281249999998e-05 1.8 1.8238839285714285e-05 0.0 1.824330357142857e-05 0.0 1.8243861607142856e-05 1.8
+ 1.825613839285714e-05 1.8 1.8256696428571427e-05 0.0 1.8261160714285715e-05 0.0 1.8261718749999998e-05 1.8
+ 1.8273995535714283e-05 1.8 1.827455357142857e-05 0.0 1.8279017857142857e-05 0.0 1.827957589285714e-05 1.8
+ 1.829185267857143e-05 1.8 1.8292410714285712e-05 0.0 1.8296875e-05 0.0 1.8297433035714286e-05 1.8 1.830970982142857e-05
+ 1.8 1.8310267857142854e-05 0.0 1.831473214285714e-05 0.0 1.8315290178571428e-05 1.8
+ 1.8327566964285713e-05 1.8 1.8328125e-05 0.0 1.8332589285714284e-05 0.0 1.833314732142857e-05 1.8 1.8345424107142856e-05
+ 1.8 1.8345982142857142e-05 0.0 1.8350446428571426e-05 0.0 1.8351004464285713e-05 1.8
+ 1.8363281249999998e-05 1.8 1.8363839285714285e-05 0.0 1.836830357142857e-05 0.0 1.8368861607142855e-05 1.8
+ 1.838113839285714e-05 1.8 1.8381696428571427e-05 0.0 1.8386160714285714e-05 0.0 1.8386718749999998e-05 1.8
+ 1.8398995535714286e-05 1.8 1.839955357142857e-05 0.0 1.8404017857142857e-05 0.0 1.840457589285714e-05 1.8
+ 1.8416852678571428e-05 1.8 1.841741071428571e-05 0.0 1.8421875e-05 0.0 1.8422433035714286e-05 1.8 1.843470982142857e-05
+ 1.8 1.8435267857142857e-05 0.0 1.843973214285714e-05 0.0 1.8440290178571428e-05 1.8
+ 1.8452566964285713e-05 1.8 1.8453125e-05 0.0 1.8457589285714283e-05 0.0 1.845814732142857e-05 1.8 1.8470424107142855e-05
+ 1.8 1.8470982142857142e-05 0.0 1.8475446428571426e-05 0.0 1.8476004464285713e-05 1.8
+ 1.8488281249999998e-05 1.8 1.8488839285714284e-05 0.0 1.849330357142857e-05 0.0 1.8493861607142855e-05 1.8
+ 1.8506138392857143e-05 1.8 1.8506696428571427e-05 0.0 1.8511160714285714e-05 0.0 1.8511718749999997e-05 1.8
+ 1.8523995535714286e-05 1.8 1.852455357142857e-05 0.0 1.8529017857142856e-05 0.0 1.8529575892857143e-05 1.8
+ 1.8541852678571428e-05 1.8 1.8542410714285715e-05 0.0 1.8546875e-05 0.0 1.8547433035714285e-05 1.8 1.855970982142857e-05
+ 1.8 1.8560267857142857e-05 0.0 1.856473214285714e-05 0.0 1.8565290178571428e-05 1.8
+ 1.8577566964285713e-05 1.8 1.8578125e-05 0.0 1.8582589285714283e-05 0.0 1.858314732142857e-05 1.8 1.8595424107142855e-05
+ 1.8 1.859598214285714e-05 0.0 1.860044642857143e-05 0.0 1.8601004464285712e-05 1.8
+ 1.8613281249999997e-05 1.8 1.8613839285714284e-05 0.0 1.861830357142857e-05 0.0 1.8618861607142855e-05 1.8
+ 1.8631138392857143e-05 1.8 1.8631696428571426e-05 0.0 1.8636160714285714e-05 0.0 1.863671875e-05 1.8
+ 1.8648995535714285e-05 1.8 1.864955357142857e-05 0.0 1.8654017857142856e-05 0.0 1.8654575892857143e-05 1.8
+ 1.8666852678571428e-05 1.8 1.8667410714285714e-05 0.0 1.8671874999999998e-05 0.0 1.8672433035714285e-05 1.8
+ 1.868470982142857e-05 1.8 1.8685267857142857e-05 0.0 1.868973214285714e-05 0.0 1.8690290178571427e-05 1.8
+ 1.8702566964285712e-05 1.8 1.8703125e-05 0.0 1.8707589285714283e-05 0.0 1.870814732142857e-05 1.8 1.8720424107142854e-05
+ 1.8 1.872098214285714e-05 0.0 1.872544642857143e-05 0.0 1.8726004464285712e-05 1.8 1.873828125e-05 1.8
+ 1.8738839285714284e-05 0.0 1.874330357142857e-05 0.0 1.8743861607142854e-05 1.8 1.8756138392857143e-05 1.8
+ 1.8756696428571426e-05 0.0 1.8761160714285713e-05 0.0 1.876171875e-05 1.8 1.8773995535714285e-05 1.8 1.877455357142857e-05
+ 0.0 1.8779017857142855e-05 0.0 1.8779575892857142e-05 1.8 1.8791852678571427e-05 1.8
+ 1.8792410714285714e-05 0.0 1.8796874999999998e-05 0.0 1.8797433035714285e-05 1.8 1.880970982142857e-05 1.8
+ 1.8810267857142856e-05 0.0 1.881473214285714e-05 0.0 1.8815290178571427e-05 1.8 1.8827566964285712e-05 1.8 1.8828125e-05
+ 0.0 1.8832589285714286e-05 0.0 1.883314732142857e-05 1.8 1.8845424107142854e-05 1.8
+ 1.884598214285714e-05 0.0 1.8850446428571428e-05 0.0 1.885100446428571e-05 1.8 1.886328125e-05 1.8 1.8863839285714283e-05
+ 0.0 1.886830357142857e-05 0.0 1.8868861607142857e-05 1.8 1.8881138392857142e-05 1.8
+ 1.8881696428571426e-05 0.0 1.8886160714285713e-05 0.0 1.888671875e-05 1.8 1.8898995535714284e-05 1.8 1.889955357142857e-05
+ 0.0 1.8904017857142855e-05 0.0 1.8904575892857142e-05 1.8 1.8916852678571427e-05 1.8
+ 1.8917410714285714e-05 0.0 1.8922433035714284e-05 0.0 1.892299107142857e-05 1.8 1.8934151785714286e-05 1.8
+ 1.893470982142857e-05 0.0 1.8940290178571427e-05 0.0 1.8940848214285713e-05 1.8 1.8952008928571428e-05 1.8
+ 1.895256696428571e-05 0.0 1.895814732142857e-05 0.0 1.8958705357142856e-05 1.8 1.896986607142857e-05 1.8
+ 1.8970424107142857e-05 0.0 1.8976004464285715e-05 0.0 1.8976562499999998e-05 1.8 1.8987723214285713e-05 1.8
+ 1.898828125e-05 0.0 1.8993861607142857e-05 0.0 1.899441964285714e-05 1.8 1.9005580357142855e-05 1.8
+ 1.9006138392857142e-05 0.0 1.901171875e-05 0.0 1.9012276785714286e-05 1.8 1.9023437499999997e-05 1.8
+ 1.9023995535714284e-05 0.0 1.902957589285714e-05 0.0 1.9030133928571428e-05 1.8 1.9041294642857143e-05 1.8
+ 1.9041852678571426e-05 0.0 1.9047433035714284e-05 0.0 1.904799107142857e-05 1.8 1.9059151785714285e-05 1.8
+ 1.905970982142857e-05 0.0 1.9065290178571426e-05 0.0 1.9065848214285713e-05 1.8 1.9077008928571428e-05 1.8
+ 1.9077566964285714e-05 0.0 1.908314732142857e-05 0.0 1.9083705357142855e-05 1.8 1.909486607142857e-05 1.8
+ 1.9095424107142857e-05 0.0 1.9101004464285714e-05 0.0 1.9101562499999998e-05 1.8 1.9112723214285712e-05 1.8
+ 1.911328125e-05 0.0 1.9118861607142857e-05 0.0 1.911941964285714e-05 1.8 1.9130580357142855e-05 1.8
+ 1.913113839285714e-05 0.0 1.913671875e-05 0.0 1.9137276785714286e-05 1.8 1.9148437499999997e-05 1.8
+ 1.9148995535714284e-05 0.0 1.915457589285714e-05 0.0 1.9155133928571428e-05 1.8 1.9166294642857143e-05 1.8
+ 1.9166852678571426e-05 0.0 1.9172433035714284e-05 0.0 1.917299107142857e-05 1.8 1.9184151785714285e-05 1.8
+ 1.918470982142857e-05 0.0 1.9190290178571426e-05 0.0 1.9190848214285713e-05 1.8 1.9202008928571427e-05 1.8
+ 1.9202566964285714e-05 0.0 1.920814732142857e-05 0.0 1.9208705357142855e-05 1.8 1.921986607142857e-05 1.8
+ 1.9220424107142856e-05 0.0 1.9226004464285714e-05 0.0 1.9226562499999997e-05 1.8 1.9237723214285712e-05 1.8
+ 1.923828125e-05 0.0 1.9243861607142856e-05 0.0 1.9244419642857143e-05 1.8 1.9255580357142854e-05 1.8
+ 1.925613839285714e-05 0.0 1.926171875e-05 0.0 1.9262276785714285e-05 1.8 1.92734375e-05 1.8 1.9273995535714283e-05 0.0
+ 1.927957589285714e-05 0.0 1.9280133928571428e-05 1.8 1.9291294642857142e-05 1.8 1.9291852678571426e-05 0.0
+ 1.9297433035714283e-05 0.0 1.929799107142857e-05 1.8 1.9309151785714285e-05 1.8 1.930970982142857e-05 0.0
+ 1.931529017857143e-05 0.0 1.9315848214285712e-05 1.8 1.9327008928571427e-05 1.8 1.9327566964285714e-05 0.0
+ 1.9333705357142855e-05 0.0 1.933426339285714e-05 1.8 1.9344308035714286e-05 1.8 1.934486607142857e-05 0.0 1.93515625e-05
+ 0.0 1.9352120535714284e-05 1.8 1.936216517857143e-05 1.8 1.936272321428571e-05 0.0
+ 1.9369419642857143e-05 0.0 1.9369977678571426e-05 1.8 1.938002232142857e-05 1.8 1.9380580357142857e-05 0.0
+ 1.9387276785714285e-05 0.0 1.938783482142857e-05 1.8 1.9397879464285713e-05 1.8 1.93984375e-05 0.0 1.9405133928571427e-05
+ 0.0 1.9405691964285714e-05 1.8 1.9415736607142855e-05 1.8 1.9416294642857142e-05 0.0
+ 1.942299107142857e-05 0.0 1.9423549107142856e-05 1.8 1.9433593749999998e-05 1.8 1.9434151785714284e-05 0.0
+ 1.9440848214285712e-05 0.0 1.944140625e-05 1.8 1.945145089285714e-05 1.8 1.9452008928571427e-05 0.0 1.9458705357142854e-05
+ 0.0 1.945926339285714e-05 1.8 1.9469308035714286e-05 1.8 1.946986607142857e-05 0.0 1.94765625e-05 0.0
+ 1.9477120535714283e-05 1.8 1.9487165178571428e-05 1.8 1.948772321428571e-05 0.0 1.9494419642857142e-05 0.0
+ 1.9494977678571426e-05 1.8 1.950502232142857e-05 1.8 1.9505580357142857e-05 0.0 1.9512276785714285e-05 0.0
+ 1.951283482142857e-05 1.8 1.9522879464285713e-05 1.8 1.95234375e-05 0.0 1.9530133928571427e-05 0.0 1.9530691964285714e-05
+ 1.8 1.9540736607142855e-05 1.8 1.954129464285714e-05 0.0 1.954799107142857e-05 0.0
+ 1.9548549107142856e-05 1.8 1.9558593749999997e-05 1.8 1.9559151785714284e-05 0.0 1.956584821428571e-05 0.0
+ 1.9566406249999998e-05 1.8 1.9576450892857143e-05 1.8 1.9577008928571426e-05 0.0 1.9583705357142857e-05 0.0
+ 1.958426339285714e-05 1.8 1.9594308035714285e-05 1.8 1.959486607142857e-05 0.0 1.96015625e-05 0.0 1.9602120535714283e-05
+ 1.8 1.9612165178571428e-05 1.8 1.9612723214285714e-05 0.0 1.9619419642857142e-05 0.0
+ 1.961997767857143e-05 1.8 1.963002232142857e-05 1.8 1.9630580357142857e-05 0.0 1.9637276785714284e-05 0.0
+ 1.963783482142857e-05 1.8 1.9647879464285712e-05 1.8 1.96484375e-05 0.0 1.9655133928571427e-05 0.0 1.9655691964285713e-05
+ 1.8 1.9665736607142855e-05 1.8 1.966629464285714e-05 0.0 1.967299107142857e-05 0.0
+ 1.9673549107142856e-05 1.8 1.9683035714285714e-05 1.8 1.9683593749999997e-05 0.0 1.9691406249999998e-05 0.0
+ 1.9691964285714285e-05 1.8 1.9700892857142856e-05 1.8 1.9701450892857143e-05 0.0 1.970926339285714e-05 0.0
+ 1.9709821428571427e-05 1.8 1.9718749999999998e-05 1.8 1.9719308035714285e-05 0.0 1.9727120535714286e-05 0.0
+ 1.972767857142857e-05 1.8 1.973660714285714e-05 1.8 1.9737165178571427e-05 0.0 1.9744977678571428e-05 0.0
+ 1.974553571428571e-05 1.8 1.9754464285714283e-05 1.8 1.975502232142857e-05 0.0 1.976283482142857e-05 0.0
+ 1.9763392857142857e-05 1.8 1.977232142857143e-05 1.8 1.9772879464285712e-05 0.0 1.9780691964285713e-05 0.0 1.978125e-05
+ 1.8 1.979017857142857e-05 1.8 1.9790736607142854e-05 0.0 1.9798549107142855e-05 0.0
+ 1.9799107142857142e-05 1.8 1.9808035714285713e-05 1.8 1.980859375e-05 0.0 1.9816406249999998e-05 0.0
+ 1.9816964285714284e-05 1.8 1.9825892857142856e-05 1.8 1.9826450892857142e-05 0.0 1.983426339285714e-05 0.0
+ 1.9834821428571427e-05 1.8 1.9843749999999998e-05 1.8 1.9844308035714285e-05 0.0 1.9852120535714286e-05 0.0
+ 1.985267857142857e-05 1.8 1.986160714285714e-05 1.8 1.9862165178571427e-05 0.0 1.9869977678571428e-05 0.0
+ 1.987053571428571e-05 1.8 1.9879464285714286e-05 1.8 1.988002232142857e-05 0.0 1.988783482142857e-05 0.0
+ 1.9888392857142857e-05 1.8 1.9897321428571428e-05 1.8 1.989787946428571e-05 0.0 1.9905691964285713e-05 0.0 1.990625e-05
+ 1.8 1.991517857142857e-05 1.8 1.9915736607142857e-05 0.0 1.9923549107142855e-05 0.0
+ 1.992410714285714e-05 1.8 1.9933035714285713e-05 1.8 1.993359375e-05 0.0 1.9941406249999997e-05 0.0
+ 1.9941964285714284e-05 1.8 1.9950892857142855e-05 1.8 1.9951450892857142e-05 0.0 1.9959263392857143e-05 0.0
+ 1.9959821428571426e-05 1.8 1.9968749999999997e-05 1.8 1.9969308035714284e-05 0.0 1.9977120535714285e-05 0.0
+ 1.997767857142857e-05 1.8 1.998660714285714e-05 1.8 1.9987165178571427e-05 0.0 1.9994977678571428e-05 0.0
+ 1.9995535714285714e-05 1.8 2.000390625e-05 1.8 2.0004464285714286e-05 0.0 2.0013392857142857e-05 0.0 2.001395089285714e-05
+ 1.8 2.002176339285714e-05 1.8 2.0022321428571428e-05 0.0 2.003125e-05 0.0 2.0031808035714286e-05 1.8
+ 2.0039620535714283e-05 1.8 2.004017857142857e-05 0.0 2.004910714285714e-05 0.0 2.0049665178571428e-05 1.8
+ 2.0057477678571426e-05 1.8 2.0058035714285712e-05 0.0 2.0066964285714284e-05 0.0 2.006752232142857e-05 1.8
+ 2.007533482142857e-05 1.8 2.0075892857142855e-05 0.0 2.0084821428571426e-05 0.0 2.0085379464285713e-05 1.8
+ 2.0093191964285714e-05 1.8 2.0093749999999997e-05 0.0 2.0102678571428568e-05 0.0 2.0103236607142855e-05 1.8
+ 2.0111049107142856e-05 1.8 2.0111607142857143e-05 0.0 2.0120535714285714e-05 0.0 2.0121093749999997e-05 1.8
+ 2.012890625e-05 1.8 2.0129464285714285e-05 0.0 2.0138392857142856e-05 0.0 2.0138950892857143e-05 1.8
+ 2.014676339285714e-05 1.8 2.0147321428571427e-05 0.0 2.015625e-05 0.0 2.0156808035714285e-05 1.8 2.0164620535714283e-05
+ 1.8 2.016517857142857e-05 0.0 2.017410714285714e-05 0.0 2.0174665178571428e-05 1.8
+ 2.018247767857143e-05 1.8 2.0183035714285712e-05 0.0 2.0191964285714283e-05 0.0 2.019252232142857e-05 1.8
+ 2.020033482142857e-05 1.8 2.0200892857142854e-05 0.0 2.0209821428571426e-05 0.0 2.0210379464285712e-05 1.8
+ 2.0218191964285713e-05 1.8 2.021875e-05 0.0 2.022767857142857e-05 0.0 2.0228236607142855e-05 1.8 2.0236049107142856e-05
+ 1.8 2.0236607142857143e-05 0.0 2.0245535714285714e-05 0.0 2.0246093749999997e-05 1.8
+ 2.0253906249999998e-05 1.8 2.0254464285714285e-05 0.0 2.0263392857142856e-05 0.0 2.0263950892857143e-05 1.8
+ 2.027176339285714e-05 1.8 2.0272321428571427e-05 0.0 2.028125e-05 0.0 2.0281808035714285e-05 1.8 2.0289620535714283e-05
+ 1.8 2.029017857142857e-05 0.0 2.029910714285714e-05 0.0 2.0299665178571427e-05 1.8
+ 2.030747767857143e-05 1.8 2.0308035714285712e-05 0.0 2.0316964285714283e-05 0.0 2.031752232142857e-05 1.8
+ 2.0324776785714284e-05 1.8 2.032533482142857e-05 0.0 2.0335379464285712e-05 0.0 2.03359375e-05 1.8 2.0342633928571426e-05
+ 1.8 2.0343191964285713e-05 0.0 2.0353236607142854e-05 0.0 2.035379464285714e-05 1.8
+ 2.036049107142857e-05 1.8 2.0361049107142855e-05 0.0 2.037109375e-05 0.0 2.0371651785714283e-05 1.8
+ 2.0378348214285714e-05 1.8 2.0378906249999998e-05 0.0 2.0388950892857142e-05 0.0 2.0389508928571426e-05 1.8
+ 2.0396205357142857e-05 1.8 2.039676339285714e-05 0.0 2.0406808035714285e-05 0.0 2.040736607142857e-05 1.8 2.04140625e-05
+ 1.8 2.0414620535714286e-05 0.0 2.0424665178571427e-05 0.0 2.0425223214285714e-05 1.8
+ 2.043191964285714e-05 1.8 2.0432477678571428e-05 0.0 2.044252232142857e-05 0.0 2.0443080357142856e-05 1.8
+ 2.0449776785714284e-05 1.8 2.045033482142857e-05 0.0 2.046037946428571e-05 0.0 2.04609375e-05 1.8 2.0467633928571426e-05
+ 1.8 2.0468191964285713e-05 0.0 2.0478236607142854e-05 0.0 2.047879464285714e-05 1.8
+ 2.0485491071428568e-05 1.8 2.0486049107142855e-05 0.0 2.049609375e-05 0.0 2.0496651785714283e-05 1.8
+ 2.0503348214285714e-05 1.8 2.0503906249999997e-05 0.0 2.0513950892857142e-05 0.0 2.0514508928571425e-05 1.8
+ 2.0521205357142856e-05 1.8 2.0521763392857143e-05 0.0 2.0531808035714284e-05 0.0 2.053236607142857e-05 1.8 2.05390625e-05
+ 1.8 2.0539620535714285e-05 0.0 2.0549665178571427e-05 0.0 2.0550223214285713e-05 1.8
+ 2.055691964285714e-05 1.8 2.0557477678571428e-05 0.0 2.056752232142857e-05 0.0 2.0568080357142856e-05 1.8
+ 2.0574776785714283e-05 1.8 2.057533482142857e-05 0.0 2.058537946428571e-05 0.0 2.0585937499999998e-05 1.8
+ 2.0592633928571426e-05 1.8 2.0593191964285712e-05 0.0 2.0603236607142857e-05 0.0 2.060379464285714e-05 1.8
+ 2.061049107142857e-05 1.8 2.0611049107142855e-05 0.0 2.062109375e-05 0.0 2.0621651785714283e-05 1.8
+ 2.0628348214285714e-05 1.8 2.0628906249999997e-05 0.0 2.063895089285714e-05 0.0 2.063950892857143e-05 1.8
+ 2.0646205357142856e-05 1.8 2.0646763392857143e-05 0.0 2.0656808035714284e-05 0.0 2.065736607142857e-05 1.8
+ 2.0664062499999998e-05 1.8 2.0664620535714285e-05 0.0 2.0675223214285713e-05 0.0 2.067578125e-05 1.8
+ 2.0681361607142857e-05 1.8 2.068191964285714e-05 0.0 2.0693080357142855e-05 0.0 2.0693638392857142e-05 1.8 2.069921875e-05
+ 1.8 2.0699776785714283e-05 0.0 2.0710937499999998e-05 0.0 2.0711495535714284e-05 1.8
+ 2.0717075892857142e-05 1.8 2.071763392857143e-05 0.0 2.072879464285714e-05 0.0 2.0729352678571427e-05 1.8
+ 2.0734933035714284e-05 1.8 2.073549107142857e-05 0.0 2.0746651785714286e-05 0.0 2.074720982142857e-05 1.8
+ 2.0752790178571427e-05 1.8 2.0753348214285713e-05 0.0 2.0764508928571428e-05 0.0 2.076506696428571e-05 1.8
+ 2.077064732142857e-05 1.8 2.0771205357142856e-05 0.0 2.078236607142857e-05 0.0 2.0782924107142857e-05 1.8
+ 2.078850446428571e-05 1.8 2.0789062499999998e-05 0.0 2.0800223214285713e-05 0.0 2.080078125e-05 1.8
+ 2.0806361607142857e-05 1.8 2.080691964285714e-05 0.0 2.0818080357142855e-05 0.0 2.0818638392857142e-05 1.8 2.082421875e-05
+ 1.8 2.0824776785714283e-05 0.0 2.0835937499999997e-05 0.0 2.0836495535714284e-05 1.8
+ 2.084207589285714e-05 1.8 2.0842633928571428e-05 0.0 2.085379464285714e-05 0.0 2.0854352678571426e-05 1.8
+ 2.0859933035714284e-05 1.8 2.086049107142857e-05 0.0 2.0871651785714285e-05 0.0 2.087220982142857e-05 1.8
+ 2.0877790178571426e-05 1.8 2.0878348214285713e-05 0.0 2.0889508928571428e-05 0.0 2.089006696428571e-05 1.8
+ 2.089564732142857e-05 1.8 2.0896205357142855e-05 0.0 2.090736607142857e-05 0.0 2.0907924107142857e-05 1.8
+ 2.0913504464285714e-05 1.8 2.0914062499999998e-05 0.0 2.0925223214285712e-05 0.0 2.092578125e-05 1.8
+ 2.0931361607142857e-05 1.8 2.093191964285714e-05 0.0 2.0943080357142855e-05 0.0 2.094363839285714e-05 1.8 2.094921875e-05
+ 1.8 2.0949776785714286e-05 0.0 2.0960937499999997e-05 0.0 2.0961495535714284e-05 1.8
+ 2.096707589285714e-05 1.8 2.0967633928571428e-05 0.0 2.0978794642857143e-05 0.0 2.0979352678571426e-05 1.8
+ 2.0984933035714284e-05 1.8 2.098549107142857e-05 0.0 2.0996651785714285e-05 0.0 2.099720982142857e-05 1.8
+ 2.1002790178571426e-05 1.8 2.1003348214285713e-05 0.0 2.1014508928571427e-05 0.0 2.1015066964285714e-05 1.8
+ 2.102064732142857e-05 1.8 2.1021205357142855e-05 0.0 2.103236607142857e-05 0.0 2.1032924107142856e-05 1.8
+ 2.1038504464285714e-05 1.8 2.1039062499999997e-05 0.0 2.1050223214285712e-05 0.0 2.105078125e-05 1.8
+ 2.1056361607142856e-05 1.8 2.1056919642857143e-05 0.0 2.1068080357142854e-05 0.0 2.106863839285714e-05 1.8 2.107421875e-05
+ 1.8 2.1074776785714285e-05 0.0 2.1086495535714283e-05 0.0 2.108705357142857e-05 1.8
+ 2.1091517857142854e-05 1.8 2.109207589285714e-05 0.0 2.1104352678571426e-05 0.0 2.1104910714285713e-05 1.8 2.1109375e-05
+ 1.8 2.1109933035714283e-05 0.0 2.112220982142857e-05 0.0 2.1122767857142855e-05 1.8
+ 2.1127232142857142e-05 1.8 2.1127790178571425e-05 0.0 2.1140066964285714e-05 0.0 2.1140624999999997e-05 1.8
+ 2.1145089285714284e-05 1.8 2.114564732142857e-05 0.0 2.1157924107142856e-05 0.0 2.1158482142857143e-05 1.8
+ 2.1162946428571427e-05 1.8 2.1163504464285714e-05 0.0 2.117578125e-05 0.0 2.1176339285714285e-05 1.8 2.118080357142857e-05
+ 1.8 2.1181361607142856e-05 0.0 2.119363839285714e-05 0.0 2.1194196428571428e-05 1.8
+ 2.119866071428571e-05 1.8 2.1199218749999998e-05 0.0 2.1211495535714283e-05 0.0 2.121205357142857e-05 1.8
+ 2.1216517857142857e-05 1.8 2.121707589285714e-05 0.0 2.1229352678571425e-05 0.0 2.1229910714285712e-05 1.8 2.1234375e-05
+ 1.8 2.1234933035714283e-05 0.0 2.124720982142857e-05 0.0 2.1247767857142855e-05 1.8
+ 2.1252232142857142e-05 1.8 2.125279017857143e-05 0.0 2.1265066964285713e-05 0.0 2.1265624999999997e-05 1.8
+ 2.1270089285714284e-05 1.8 2.127064732142857e-05 0.0 2.1282924107142856e-05 0.0 2.1283482142857143e-05 1.8
+ 2.1287946428571426e-05 1.8 2.1288504464285713e-05 0.0 2.1300781249999998e-05 0.0 2.1301339285714285e-05 1.8
+ 2.130580357142857e-05 1.8 2.1306361607142856e-05 0.0 2.131863839285714e-05 0.0 2.1319196428571427e-05 1.8
+ 2.132366071428571e-05 1.8 2.1324218749999998e-05 0.0 2.1336495535714283e-05 0.0 2.133705357142857e-05 1.8
+ 2.1341517857142857e-05 1.8 2.134207589285714e-05 0.0 2.135435267857143e-05 0.0 2.1354910714285712e-05 1.8 2.1359375e-05
+ 1.8 2.1359933035714286e-05 0.0 2.137220982142857e-05 0.0 2.1372767857142854e-05 1.8
+ 2.137723214285714e-05 1.8 2.1377790178571428e-05 0.0 2.1390066964285713e-05 0.0 2.1390625e-05 1.8 2.1395089285714284e-05
+ 1.8 2.139564732142857e-05 0.0 2.1407924107142855e-05 0.0 2.1408482142857142e-05 1.8
+ 2.1412946428571426e-05 1.8 2.1413504464285713e-05 0.0 2.1425781249999998e-05 0.0 2.1426339285714285e-05 1.8
+ 2.143080357142857e-05 1.8 2.1431361607142855e-05 0.0 2.144363839285714e-05 0.0 2.1444196428571427e-05 1.8
+ 2.1448660714285714e-05 1.8 2.1449218749999997e-05 0.0 2.1461495535714286e-05 0.0 2.146205357142857e-05 1.8
+ 2.1466517857142856e-05 1.8 2.146707589285714e-05 0.0 2.1479352678571428e-05 0.0 2.147991071428571e-05 1.8 2.1484375e-05
+ 1.8 2.1484933035714286e-05 0.0 2.149720982142857e-05 0.0 2.1497767857142857e-05 1.8
+ 2.150223214285714e-05 1.8 2.1502790178571428e-05 0.0 2.1515066964285713e-05 0.0 2.1515625e-05 1.8 2.1520089285714283e-05
+ 1.8 2.152064732142857e-05 0.0 2.1532924107142855e-05 0.0 2.1533482142857142e-05 1.8
+ 2.1537946428571426e-05 1.8 2.1538504464285712e-05 0.0 2.1550781249999997e-05 0.0 2.1551339285714284e-05 1.8
+ 2.155580357142857e-05 1.8 2.1556361607142855e-05 0.0 2.156863839285714e-05 0.0 2.1569196428571426e-05 1.8
+ 2.1573660714285714e-05 1.8 2.1574218749999997e-05 0.0 2.1586495535714285e-05 0.0 2.158705357142857e-05 1.8
+ 2.1591517857142856e-05 1.8 2.1592075892857143e-05 0.0 2.1604352678571428e-05 0.0 2.160491071428571e-05 1.8 2.1609375e-05
+ 1.8 2.1609933035714285e-05 0.0 2.162220982142857e-05 0.0 2.1622767857142857e-05 1.8
+ 2.162723214285714e-05 1.8 2.1627790178571427e-05 0.0 2.1640066964285712e-05 0.0 2.1640625e-05 1.8 2.1645089285714283e-05
+ 1.8 2.164564732142857e-05 0.0 2.1657924107142855e-05 0.0 2.165848214285714e-05 1.8
+ 2.1662946428571425e-05 1.8 2.1663504464285712e-05 0.0 2.1675781249999997e-05 0.0 2.1676339285714284e-05 1.8
+ 2.168080357142857e-05 1.8 2.1681361607142854e-05 0.0 2.1693638392857143e-05 0.0 2.1694196428571426e-05 1.8
+ 2.1698660714285713e-05 1.8 2.1699218749999997e-05 0.0 2.1711495535714285e-05 0.0 2.171205357142857e-05 1.8
+ 2.1716517857142856e-05 1.8 2.1717075892857142e-05 0.0 2.1729352678571427e-05 0.0 2.1729910714285714e-05 1.8
+ 2.1734374999999998e-05 1.8 2.1734933035714285e-05 0.0 2.174720982142857e-05 0.0 2.1747767857142856e-05 1.8
+ 2.175223214285714e-05 1.8 2.1752790178571427e-05 0.0 2.1765066964285712e-05 0.0 2.1765625e-05 1.8 2.1770089285714283e-05
+ 1.8 2.177064732142857e-05 0.0 2.1782924107142854e-05 0.0 2.178348214285714e-05 1.8
+ 2.178794642857143e-05 1.8 2.1788504464285712e-05 0.0 2.180078125e-05 0.0 2.1801339285714283e-05 1.8 2.180580357142857e-05
+ 1.8 2.1806361607142854e-05 0.0 2.1818638392857142e-05 0.0 2.1819196428571426e-05 1.8
+ 2.1823660714285713e-05 1.8 2.182421875e-05 0.0 2.1836495535714285e-05 0.0 2.183705357142857e-05 1.8 2.1841517857142855e-05
+ 1.8 2.1842075892857142e-05 0.0 2.1854352678571427e-05 0.0 2.1854910714285714e-05 1.8
+ 2.1859374999999998e-05 1.8 2.1859933035714284e-05 0.0 2.187220982142857e-05 0.0 2.1872767857142856e-05 1.8
+ 2.187723214285714e-05 1.8 2.1877790178571427e-05 0.0 2.1890066964285712e-05 0.0 2.1890625e-05 1.8 2.1895089285714286e-05
+ 1.8 2.189564732142857e-05 0.0 2.1907924107142854e-05 0.0 2.190848214285714e-05 1.8
+ 2.1912946428571428e-05 1.8 2.191350446428571e-05 0.0 2.192578125e-05 0.0 2.1926339285714283e-05 1.8 2.193080357142857e-05
+ 1.8 2.1931361607142857e-05 0.0 2.1943638392857142e-05 0.0 2.1944196428571425e-05 1.8
+ 2.1948660714285713e-05 1.8 2.194921875e-05 0.0 2.1961495535714284e-05 0.0 2.196205357142857e-05 1.8 2.1966517857142855e-05
+ 1.8 2.1967075892857142e-05 0.0 2.1979352678571427e-05 0.0 2.1979910714285713e-05 1.8
+ 2.1984374999999997e-05 1.8 2.1984933035714284e-05 0.0 2.199720982142857e-05 0.0 2.1997767857142856e-05 1.8
+ 2.200223214285714e-05 1.8 2.2002790178571426e-05 0.0 2.201506696428571e-05 0.0 2.2015624999999998e-05 1.8
+ 2.2020089285714285e-05 1.8 2.202064732142857e-05 0.0 2.2032924107142857e-05 0.0 2.203348214285714e-05 1.8
+ 2.2037946428571428e-05 1.8 2.203850446428571e-05 0.0 2.205078125e-05 0.0 2.2051339285714283e-05 1.8 2.205580357142857e-05
+ 1.8 2.2056361607142857e-05 0.0 2.2068638392857142e-05 0.0 2.206919642857143e-05 1.8
+ 2.2073660714285712e-05 1.8 2.207421875e-05 0.0 2.2086495535714284e-05 0.0 2.208705357142857e-05 1.8 2.2091517857142855e-05
+ 1.8 2.209207589285714e-05 0.0 2.2104352678571426e-05 0.0 2.2104910714285713e-05 1.8
+ 2.2109374999999997e-05 1.8 2.2109933035714284e-05 0.0 2.212220982142857e-05 0.0 2.2122767857142855e-05 1.8
+ 2.2127232142857143e-05 1.8 2.2127790178571426e-05 0.0 2.214006696428571e-05 0.0 2.2140624999999998e-05 1.8
+ 2.2145089285714285e-05 1.8 2.214564732142857e-05 0.0 2.2157924107142857e-05 0.0 2.215848214285714e-05 1.8
+ 2.2162946428571427e-05 1.8 2.2163504464285714e-05 0.0 2.217578125e-05 0.0 2.2176339285714286e-05 1.8 2.218080357142857e-05
+ 1.8 2.2181361607142856e-05 0.0 2.219363839285714e-05 0.0 2.2194196428571428e-05 1.8
+ 2.2198660714285712e-05 1.8 2.219921875e-05 0.0 2.2211495535714284e-05 0.0 2.221205357142857e-05 1.8 2.2216517857142854e-05
+ 1.8 2.221707589285714e-05 0.0 2.2229352678571426e-05 0.0 2.2229910714285713e-05 1.8 2.2234375e-05 1.8
+ 2.2234933035714283e-05 0.0 2.224720982142857e-05 0.0 2.2247767857142855e-05 1.8 2.2252232142857142e-05 1.8
+ 2.2252790178571426e-05 0.0 2.2265066964285714e-05 0.0 2.2265624999999997e-05 1.8 2.2270089285714285e-05 1.8
+ 2.227064732142857e-05 0.0 2.2282924107142856e-05 0.0 2.228348214285714e-05 1.8 2.2287946428571427e-05 1.8
+ 2.2288504464285714e-05 0.0 2.230078125e-05 0.0 2.2301339285714285e-05 1.8 2.230580357142857e-05 1.8 2.2306361607142856e-05
+ 0.0 2.231863839285714e-05 0.0 2.2319196428571428e-05 1.8 2.232366071428571e-05 1.8 2.232421875e-05 0.0
+ 2.2336495535714283e-05 0.0 2.233705357142857e-05 1.8 2.2341517857142854e-05 1.8 2.234207589285714e-05 0.0
+ 2.2354352678571426e-05 0.0 2.2354910714285712e-05 1.8 2.2359375e-05 1.8 2.2359933035714283e-05 0.0 2.237220982142857e-05
+ 0.0 2.2372767857142855e-05 1.8 2.2377232142857142e-05 1.8 2.2377790178571425e-05 0.0
+ 2.2390066964285714e-05 0.0 2.2390624999999997e-05 1.8 2.2395089285714284e-05 1.8 2.239564732142857e-05 0.0
+ 2.2407924107142856e-05 0.0 2.2408482142857143e-05 1.8 2.2412946428571427e-05 1.8 2.2413504464285713e-05 0.0
+ 2.242578125e-05 0.0 2.2426339285714285e-05 1.8 2.243080357142857e-05 1.8 2.2431361607142856e-05 0.0
+ 2.244363839285714e-05 0.0 2.2444196428571427e-05 1.8 2.244866071428571e-05 1.8 2.2449218749999998e-05 0.0
+ 2.2461495535714283e-05 0.0 2.246205357142857e-05 1.8 2.2466517857142857e-05 1.8 2.246707589285714e-05 0.0
+ 2.2479352678571425e-05 0.0 2.2479910714285712e-05 1.8 2.2484375e-05 1.8 2.2484933035714283e-05 0.0 2.249720982142857e-05
+ 0.0 2.2497767857142854e-05 1.8 2.250223214285714e-05 1.8 2.250279017857143e-05 0.0
+ 2.2515066964285713e-05 0.0 2.2515624999999997e-05 1.8 2.2520089285714284e-05 1.8 2.252064732142857e-05 0.0
+ 2.2532924107142856e-05 0.0 2.2533482142857142e-05 1.8 2.2537946428571426e-05 1.8 2.2538504464285713e-05 0.0
+ 2.2550781249999998e-05 0.0 2.2551339285714285e-05 1.8 2.255580357142857e-05 1.8 2.2556361607142855e-05 0.0
+ 2.256863839285714e-05 0.0 2.2569196428571427e-05 1.8 2.2573660714285714e-05 1.8 2.2574218749999998e-05 0.0
+ 2.2586495535714283e-05 0.0 2.258705357142857e-05 1.8 2.2591517857142857e-05 1.8 2.259207589285714e-05 0.0
+ 2.260435267857143e-05 0.0 2.2604910714285712e-05 1.8 2.2609375e-05 1.8 2.2609933035714286e-05 0.0 2.262220982142857e-05
+ 0.0 2.2622767857142854e-05 1.8 2.262723214285714e-05 1.8 2.2627790178571428e-05 0.0
+ 2.2640066964285713e-05 0.0 2.2640625e-05 1.8 2.2645089285714284e-05 1.8 2.264564732142857e-05 0.0 2.2657924107142855e-05
+ 0.0 2.2658482142857142e-05 1.8 2.2662946428571426e-05 1.8 2.2663504464285713e-05 0.0
+ 2.2675781249999998e-05 0.0 2.2676339285714284e-05 1.8 2.2680803571428568e-05 1.8 2.2681361607142855e-05 0.0
+ 2.269363839285714e-05 0.0 2.2694196428571427e-05 1.8 2.2698660714285714e-05 1.8 2.2699218749999997e-05 0.0
+ 2.2711495535714286e-05 0.0 2.271205357142857e-05 1.8 2.2716517857142856e-05 1.8 2.271707589285714e-05 0.0
+ 2.2729352678571428e-05 0.0 2.272991071428571e-05 1.8 2.2734375e-05 1.8 2.2734933035714285e-05 0.0 2.274720982142857e-05
+ 0.0 2.2747767857142857e-05 1.8 2.275223214285714e-05 1.8 2.2752790178571428e-05 0.0
+ 2.2765066964285713e-05 0.0 2.2765625e-05 1.8 2.2770089285714283e-05 1.8 2.277064732142857e-05 0.0 2.2782924107142855e-05
+ 0.0 2.2783482142857142e-05 1.8 2.2787946428571426e-05 1.8 2.2788504464285712e-05 0.0
+ 2.2800781249999997e-05 0.0 2.2801339285714284e-05 1.8 2.280580357142857e-05 1.8 2.2806361607142855e-05 0.0
+ 2.281863839285714e-05 0.0 2.2819196428571426e-05 1.8 2.2823660714285714e-05 1.8 2.2824218749999997e-05 0.0
+ 2.2836495535714285e-05 0.0 2.283705357142857e-05 1.8 2.2841517857142856e-05 1.8 2.2842075892857143e-05 0.0
+ 2.2854352678571428e-05 0.0 2.285491071428571e-05 1.8 2.2859374999999998e-05 1.8 2.2859933035714285e-05 0.0
+ 2.287220982142857e-05 0.0 2.2872767857142857e-05 1.8 2.287723214285714e-05 1.8 2.2877790178571427e-05 0.0
+ 2.2890066964285712e-05 0.0 2.2890625e-05 1.8 2.2895089285714283e-05 1.8 2.289564732142857e-05 0.0 2.2907924107142855e-05
+ 0.0 2.290848214285714e-05 1.8 2.2912946428571425e-05 1.8 2.2913504464285712e-05 0.0
+ 2.2925223214285714e-05 0.0 2.2925781249999997e-05 1.8 2.2931361607142854e-05 1.8 2.293191964285714e-05 0.0
+ 2.2943080357142856e-05 0.0 2.2943638392857143e-05 1.8 2.2949218749999997e-05 1.8 2.2949776785714283e-05 0.0
+ 2.2960937499999998e-05 0.0 2.2961495535714285e-05 1.8 2.2967075892857142e-05 1.8 2.2967633928571426e-05 0.0
+ 2.297879464285714e-05 0.0 2.2979352678571427e-05 1.8 2.2984933035714285e-05 1.8 2.298549107142857e-05 0.0
+ 2.2996651785714283e-05 0.0 2.299720982142857e-05 1.8 2.3002790178571427e-05 1.8 2.3003348214285714e-05 0.0
+ 2.301450892857143e-05 0.0 2.3015066964285712e-05 1.8 2.302064732142857e-05 1.8 2.3021205357142856e-05 0.0
+ 2.303236607142857e-05 0.0 2.3032924107142854e-05 1.8 2.303850446428571e-05 1.8 2.30390625e-05 0.0 2.3050223214285713e-05
+ 0.0 2.305078125e-05 1.8 2.3056361607142854e-05 1.8 2.305691964285714e-05 0.0 2.3068080357142856e-05 0.0
+ 2.3068638392857142e-05 1.8 2.307421875e-05 1.8 2.3074776785714283e-05 0.0 2.3085937499999998e-05 0.0
+ 2.3086495535714285e-05 1.8 2.3092075892857142e-05 1.8 2.3092633928571425e-05 0.0 2.310379464285714e-05 0.0
+ 2.3104352678571427e-05 1.8 2.3109933035714284e-05 1.8 2.311049107142857e-05 0.0 2.3121651785714283e-05 0.0
+ 2.312220982142857e-05 1.8 2.3127790178571427e-05 1.8 2.3128348214285713e-05 0.0 2.3139508928571428e-05 0.0
+ 2.314006696428571e-05 1.8 2.314564732142857e-05 1.8 2.3146205357142856e-05 0.0 2.315736607142857e-05 0.0
+ 2.3157924107142854e-05 1.8 2.316350446428571e-05 1.8 2.3164062499999998e-05 0.0 2.3175223214285713e-05 0.0 2.317578125e-05
+ 1.8 2.3181361607142857e-05 1.8 2.318191964285714e-05 0.0 2.3193080357142855e-05 0.0
+ 2.3193638392857142e-05 1.8 2.319921875e-05 1.8 2.3199776785714283e-05 0.0 2.3210937499999998e-05 0.0
+ 2.3211495535714284e-05 1.8 2.321707589285714e-05 1.8 2.321763392857143e-05 0.0 2.322879464285714e-05 0.0
+ 2.3229352678571427e-05 1.8 2.3234933035714284e-05 1.8 2.323549107142857e-05 0.0 2.3246651785714286e-05 0.0
+ 2.324720982142857e-05 1.8 2.3252790178571426e-05 1.8 2.3253348214285713e-05 0.0 2.3264508928571428e-05 0.0
+ 2.326506696428571e-05 1.8 2.327064732142857e-05 1.8 2.3271205357142855e-05 0.0 2.328236607142857e-05 0.0
+ 2.3282924107142857e-05 1.8 2.328850446428571e-05 1.8 2.3289062499999998e-05 0.0 2.3300223214285713e-05 0.0 2.330078125e-05
+ 1.8 2.3306361607142857e-05 1.8 2.330691964285714e-05 0.0 2.3318080357142855e-05 0.0
+ 2.331863839285714e-05 1.8 2.332421875e-05 1.8 2.3324776785714282e-05 0.0 2.3335379464285714e-05 0.0
+ 2.3335937499999997e-05 1.8 2.3342633928571428e-05 1.8 2.334319196428571e-05 0.0 2.3353236607142856e-05 0.0
+ 2.335379464285714e-05 1.8 2.336049107142857e-05 1.8 2.3361049107142854e-05 0.0 2.337109375e-05 0.0 2.3371651785714285e-05
+ 1.8 2.3378348214285713e-05 1.8 2.337890625e-05 0.0 2.338895089285714e-05 0.0 2.3389508928571428e-05 1.8
+ 2.3396205357142855e-05 1.8 2.3396763392857142e-05 0.0 2.3406808035714283e-05 0.0 2.340736607142857e-05 1.8
+ 2.3414062499999997e-05 1.8 2.3414620535714284e-05 0.0 2.3424665178571425e-05 0.0 2.3425223214285712e-05 1.8
+ 2.343191964285714e-05 1.8 2.3432477678571426e-05 0.0 2.344252232142857e-05 0.0 2.3443080357142854e-05 1.8
+ 2.3449776785714285e-05 1.8 2.345033482142857e-05 0.0 2.3460379464285713e-05 0.0 2.3460937499999997e-05 1.8
+ 2.3467633928571428e-05 1.8 2.346819196428571e-05 0.0 2.3478236607142856e-05 0.0 2.3478794642857143e-05 1.8
+ 2.348549107142857e-05 1.8 2.3486049107142857e-05 0.0 2.3496093749999998e-05 0.0 2.3496651785714285e-05 1.8
+ 2.3503348214285712e-05 1.8 2.350390625e-05 0.0 2.351395089285714e-05 0.0 2.3514508928571427e-05 1.8 2.3521205357142855e-05
+ 1.8 2.352176339285714e-05 0.0 2.3531808035714283e-05 0.0 2.353236607142857e-05 1.8
+ 2.3539062499999997e-05 1.8 2.3539620535714284e-05 0.0 2.354966517857143e-05 0.0 2.3550223214285712e-05 1.8
+ 2.3556919642857143e-05 1.8 2.3557477678571426e-05 0.0 2.356752232142857e-05 0.0 2.3568080357142854e-05 1.8
+ 2.3574776785714285e-05 1.8 2.357533482142857e-05 0.0 2.3585379464285713e-05 0.0 2.35859375e-05 1.8 2.3592633928571427e-05
+ 1.8 2.3593191964285714e-05 0.0 2.3603236607142855e-05 0.0 2.3603794642857142e-05 1.8
+ 2.361049107142857e-05 1.8 2.3611049107142856e-05 0.0 2.3621093749999998e-05 0.0 2.3621651785714285e-05 1.8
+ 2.3628348214285712e-05 1.8 2.362890625e-05 0.0 2.363895089285714e-05 0.0 2.3639508928571427e-05 1.8 2.3646205357142854e-05
+ 1.8 2.364676339285714e-05 0.0 2.3656808035714282e-05 0.0 2.365736607142857e-05 1.8
+ 2.3664062499999997e-05 1.8 2.3664620535714283e-05 0.0 2.3674665178571428e-05 0.0 2.367522321428571e-05 1.8
+ 2.3682477678571426e-05 1.8 2.3683035714285713e-05 0.0 2.3691964285714284e-05 0.0 2.369252232142857e-05 1.8
+ 2.3700334821428568e-05 1.8 2.3700892857142855e-05 0.0 2.3709821428571426e-05 0.0 2.3710379464285713e-05 1.8
+ 2.3718191964285714e-05 1.8 2.3718749999999997e-05 0.0 2.372767857142857e-05 0.0 2.3728236607142855e-05 1.8
+ 2.3736049107142856e-05 1.8 2.373660714285714e-05 0.0 2.3745535714285714e-05 0.0 2.3746093749999997e-05 1.8 2.375390625e-05
+ 1.8 2.3754464285714285e-05 0.0 2.3763392857142856e-05 0.0 2.376395089285714e-05 1.8
+ 2.377176339285714e-05 1.8 2.3772321428571428e-05 0.0 2.378125e-05 0.0 2.3781808035714285e-05 1.8 2.3789620535714283e-05
+ 1.8 2.379017857142857e-05 0.0 2.379910714285714e-05 0.0 2.3799665178571428e-05 1.8
+ 2.3807477678571425e-05 1.8 2.3808035714285712e-05 0.0 2.3816964285714283e-05 0.0 2.381752232142857e-05 1.8
+ 2.382533482142857e-05 1.8 2.3825892857142854e-05 0.0 2.3834821428571426e-05 0.0 2.3835379464285712e-05 1.8
+ 2.3843191964285713e-05 1.8 2.3843749999999997e-05 0.0 2.385267857142857e-05 0.0 2.3853236607142855e-05 1.8
+ 2.3861049107142856e-05 1.8 2.3861607142857143e-05 0.0 2.3870535714285714e-05 0.0 2.3871093749999997e-05 1.8
+ 2.3878906249999998e-05 1.8 2.3879464285714285e-05 0.0 2.3888392857142856e-05 0.0 2.3888950892857143e-05 1.8
+ 2.389676339285714e-05 1.8 2.3897321428571427e-05 0.0 2.390625e-05 0.0 2.3906808035714285e-05 1.8 2.3914620535714283e-05
+ 1.8 2.391517857142857e-05 0.0 2.392410714285714e-05 0.0 2.3924665178571427e-05 1.8
+ 2.393247767857143e-05 1.8 2.3933035714285712e-05 0.0 2.3941964285714283e-05 0.0 2.394252232142857e-05 1.8
+ 2.395033482142857e-05 1.8 2.3950892857142854e-05 0.0 2.3959821428571425e-05 0.0 2.3960379464285712e-05 1.8
+ 2.3968191964285713e-05 1.8 2.396875e-05 0.0 2.397767857142857e-05 0.0 2.3978236607142854e-05 1.8 2.3986049107142855e-05
+ 1.8 2.3986607142857142e-05 0.0 2.3995535714285713e-05 0.0 2.3996093749999997e-05 1.8
+ 2.4004464285714284e-05 1.8 2.400502232142857e-05 0.0 2.401283482142857e-05 0.0 2.4013392857142856e-05 1.8
+ 2.4022321428571427e-05 1.8 2.4022879464285714e-05 0.0 2.403069196428571e-05 0.0 2.4031249999999998e-05 1.8
+ 2.404017857142857e-05 1.8 2.4040736607142856e-05 0.0 2.4048549107142857e-05 0.0 2.404910714285714e-05 1.8
+ 2.405803571428571e-05 1.8 2.4058593749999998e-05 0.0 2.406640625e-05 0.0 2.4066964285714283e-05 1.8
+ 2.4075892857142854e-05 1.8 2.407645089285714e-05 0.0 2.408426339285714e-05 0.0 2.408482142857143e-05 1.8 2.409375e-05 1.8
+ 2.4094308035714283e-05 0.0 2.4102120535714284e-05 0.0 2.410267857142857e-05 1.8 2.4111607142857142e-05 1.8
+ 2.4112165178571425e-05 0.0 2.4119977678571426e-05 0.0 2.4120535714285713e-05 1.8 2.4129464285714284e-05 1.8
+ 2.413002232142857e-05 0.0 2.413783482142857e-05 0.0 2.4138392857142855e-05 1.8 2.4147321428571426e-05 1.8
+ 2.4147879464285713e-05 0.0 2.415569196428571e-05 0.0 2.4156249999999998e-05 1.8 2.416517857142857e-05 1.8
+ 2.4165736607142856e-05 0.0 2.4173549107142857e-05 0.0 2.417410714285714e-05 1.8 2.418303571428571e-05 1.8
+ 2.4183593749999998e-05 0.0 2.419140625e-05 0.0 2.4191964285714286e-05 1.8 2.4200892857142857e-05 1.8 2.420145089285714e-05
+ 0.0 2.420926339285714e-05 0.0 2.4209821428571428e-05 1.8 2.421875e-05 1.8 2.4219308035714283e-05 0.0
+ 2.4227120535714284e-05 0.0 2.422767857142857e-05 1.8 2.423660714285714e-05 1.8 2.4237165178571428e-05 0.0
+ 2.4244977678571426e-05 0.0 2.4245535714285713e-05 1.8 2.4254464285714284e-05 1.8 2.425502232142857e-05 0.0
+ 2.4262834821428568e-05 0.0 2.4263392857142855e-05 1.8 2.4272321428571426e-05 1.8 2.4272879464285713e-05 0.0
+ 2.4280691964285714e-05 0.0 2.4281249999999997e-05 1.8 2.429017857142857e-05 1.8 2.4290736607142855e-05 0.0
+ 2.4298549107142856e-05 0.0 2.429910714285714e-05 1.8 2.4308035714285714e-05 1.8 2.4308593749999998e-05 0.0 2.431640625e-05
+ 0.0 2.4316964285714285e-05 1.8 2.432645089285714e-05 1.8 2.4327008928571427e-05 0.0
+ 2.4333705357142854e-05 0.0 2.433426339285714e-05 1.8 2.4344308035714286e-05 1.8 2.434486607142857e-05 0.0 2.43515625e-05
+ 0.0 2.4352120535714283e-05 1.8 2.4362165178571428e-05 1.8 2.436272321428571e-05 0.0
+ 2.4369419642857142e-05 0.0 2.4369977678571426e-05 1.8 2.438002232142857e-05 1.8 2.4380580357142857e-05 0.0
+ 2.4387276785714284e-05 0.0 2.438783482142857e-05 1.8 2.4397879464285713e-05 1.8 2.43984375e-05 0.0 2.4405133928571427e-05
+ 0.0 2.4405691964285714e-05 1.8 2.4415736607142855e-05 1.8 2.441629464285714e-05 0.0
+ 2.442299107142857e-05 0.0 2.4423549107142856e-05 1.8 2.4433593749999997e-05 1.8 2.4434151785714284e-05 0.0
+ 2.444084821428571e-05 0.0 2.4441406249999998e-05 1.8 2.445145089285714e-05 1.8 2.4452008928571426e-05 0.0
+ 2.4458705357142854e-05 0.0 2.445926339285714e-05 1.8 2.4469308035714285e-05 1.8 2.446986607142857e-05 0.0 2.44765625e-05
+ 0.0 2.4477120535714283e-05 1.8 2.4487165178571428e-05 1.8 2.448772321428571e-05 0.0
+ 2.4494419642857142e-05 0.0 2.4494977678571425e-05 1.8 2.450502232142857e-05 1.8 2.4505580357142857e-05 0.0
+ 2.4512276785714284e-05 0.0 2.451283482142857e-05 1.8 2.4522879464285712e-05 1.8 2.45234375e-05 0.0 2.4530133928571426e-05
+ 0.0 2.4530691964285713e-05 1.8 2.4540736607142854e-05 1.8 2.454129464285714e-05 0.0
+ 2.454799107142857e-05 0.0 2.4548549107142856e-05 1.8 2.4558593749999997e-05 1.8 2.4559151785714284e-05 0.0
+ 2.456584821428571e-05 0.0 2.4566406249999998e-05 1.8 2.4576450892857143e-05 1.8 2.4577008928571426e-05 0.0
+ 2.4583705357142857e-05 0.0 2.458426339285714e-05 1.8 2.4594308035714285e-05 1.8 2.4594866071428568e-05 0.0 2.46015625e-05
+ 0.0 2.4602120535714283e-05 1.8 2.4612165178571427e-05 1.8 2.4612723214285714e-05 0.0
+ 2.461941964285714e-05 0.0 2.4619977678571428e-05 1.8 2.463002232142857e-05 1.8 2.4630580357142856e-05 0.0
+ 2.4637276785714284e-05 0.0 2.463783482142857e-05 1.8 2.4647879464285712e-05 1.8 2.46484375e-05 0.0 2.4655133928571426e-05
+ 0.0 2.4655691964285713e-05 1.8 2.4665736607142854e-05 1.8 2.466629464285714e-05 0.0
+ 2.4672433035714285e-05 0.0 2.467299107142857e-05 1.8 2.4684151785714283e-05 1.8 2.468470982142857e-05 0.0
+ 2.4690290178571427e-05 0.0 2.4690848214285714e-05 1.8 2.4702008928571426e-05 1.8 2.4702566964285712e-05 0.0
+ 2.470814732142857e-05 0.0 2.4708705357142856e-05 1.8 2.471986607142857e-05 1.8 2.4720424107142855e-05 0.0
+ 2.4726004464285712e-05 0.0 2.47265625e-05 1.8 2.4737723214285714e-05 1.8 2.4738281249999997e-05 0.0 2.4743861607142854e-05
+ 0.0 2.474441964285714e-05 1.8 2.4755580357142856e-05 1.8 2.4756138392857143e-05 0.0
+ 2.4761718749999997e-05 0.0 2.4762276785714283e-05 1.8 2.4773437499999998e-05 1.8 2.4773995535714285e-05 0.0
+ 2.4779575892857142e-05 0.0 2.4780133928571426e-05 1.8 2.479129464285714e-05 1.8 2.4791852678571427e-05 0.0
+ 2.4797433035714285e-05 0.0 2.4797991071428568e-05 1.8 2.4809151785714283e-05 1.8 2.480970982142857e-05 0.0
+ 2.4815290178571427e-05 0.0 2.4815848214285714e-05 1.8 2.4827008928571425e-05 1.8 2.4827566964285712e-05 0.0
+ 2.483314732142857e-05 0.0 2.4833705357142856e-05 1.8 2.484486607142857e-05 1.8 2.4845424107142854e-05 0.0
+ 2.485100446428571e-05 0.0 2.48515625e-05 1.8 2.4862723214285713e-05 1.8 2.4863281249999997e-05 0.0 2.4868861607142854e-05
+ 0.0 2.486941964285714e-05 1.8 2.4880580357142856e-05 1.8 2.4881138392857142e-05 0.0 2.488671875e-05 0.0
+ 2.4887276785714283e-05 1.8 2.4898437499999998e-05 1.8 2.4898995535714285e-05 0.0 2.4904575892857142e-05 0.0
+ 2.4905133928571425e-05 1.8 2.491629464285714e-05 1.8 2.4916852678571427e-05 0.0 2.4922433035714284e-05 0.0
+ 2.492299107142857e-05 1.8 2.4934151785714283e-05 1.8 2.493470982142857e-05 0.0 2.4940290178571427e-05 0.0
+ 2.4940848214285713e-05 1.8 2.4952008928571428e-05 1.8 2.495256696428571e-05 0.0 2.495814732142857e-05 0.0
+ 2.4958705357142856e-05 1.8 2.496986607142857e-05 1.8 2.4970424107142854e-05 0.0 2.497600446428571e-05 0.0
+ 2.4976562499999998e-05 1.8 2.4987723214285713e-05 1.8 2.498828125e-05 0.0 2.4993861607142857e-05 0.0 2.499441964285714e-05
+ 1.8 2.5005580357142855e-05 1.8 2.5006138392857142e-05 0.0 2.501171875e-05 0.0 2.5012276785714283e-05
+ 1.8 2.5023437499999998e-05 1.8 2.5023995535714284e-05 0.0 2.502957589285714e-05 0.0
+ 2.503013392857143e-05 1.8 2.504129464285714e-05 1.8 2.5041852678571427e-05 0.0 2.5047433035714284e-05 0.0
+ 2.504799107142857e-05 1.8 2.5059151785714286e-05 1.8 2.505970982142857e-05 0.0 2.5065290178571426e-05 0.0
+ 2.5065848214285713e-05 1.8 2.5077008928571428e-05 1.8 2.507756696428571e-05 0.0 2.5082589285714285e-05 0.0
+ 2.508314732142857e-05 1.8 2.5095424107142857e-05 1.8 2.509598214285714e-05 0.0 2.5100446428571428e-05 0.0
+ 2.510100446428571e-05 1.8 2.511328125e-05 1.8 2.5113839285714283e-05 0.0 2.511830357142857e-05 0.0 2.5118861607142857e-05
+ 1.8 2.513113839285714e-05 1.8 2.513169642857143e-05 0.0 2.5136160714285712e-05 0.0 2.513671875e-05 1.8
+ 2.5148995535714284e-05 1.8 2.514955357142857e-05 0.0 2.5154017857142855e-05 0.0 2.515457589285714e-05 1.8
+ 2.5166852678571426e-05 1.8 2.5167410714285713e-05 0.0 2.5171874999999997e-05 0.0 2.5172433035714284e-05 1.8
+ 2.518470982142857e-05 1.8 2.5185267857142855e-05 0.0 2.5189732142857143e-05 0.0 2.5190290178571426e-05 1.8
+ 2.520256696428571e-05 1.8 2.5203124999999998e-05 0.0 2.5207589285714285e-05 0.0 2.520814732142857e-05 1.8
+ 2.5220424107142857e-05 1.8 2.522098214285714e-05 0.0 2.5225446428571427e-05 0.0 2.5226004464285714e-05 1.8 2.523828125e-05
+ 1.8 2.5238839285714282e-05 0.0 2.524330357142857e-05 0.0 2.5243861607142856e-05 1.8
+ 2.525613839285714e-05 1.8 2.5256696428571428e-05 0.0 2.5261160714285712e-05 0.0 2.526171875e-05 1.8
+ 2.5273995535714284e-05 1.8 2.527455357142857e-05 0.0 2.5279017857142854e-05 0.0 2.527957589285714e-05 1.8
+ 2.5291852678571426e-05 1.8 2.5292410714285713e-05 0.0 2.5296874999999997e-05 0.0 2.5297433035714283e-05 1.8
+ 2.5309709821428568e-05 1.8 2.5310267857142855e-05 0.0 2.5314732142857142e-05 0.0 2.5315290178571426e-05 1.8
+ 2.5327566964285714e-05 1.8 2.5328124999999997e-05 0.0 2.5332589285714285e-05 0.0 2.5333147321428568e-05 1.8
+ 2.5345424107142856e-05 1.8 2.534598214285714e-05 0.0 2.5350446428571427e-05 0.0 2.5351004464285714e-05 1.8 2.536328125e-05
+ 1.8 2.5363839285714285e-05 0.0 2.536830357142857e-05 0.0 2.5368861607142856e-05 1.8
+ 2.538113839285714e-05 1.8 2.5381696428571428e-05 0.0 2.538616071428571e-05 0.0 2.538671875e-05 1.8 2.5398995535714283e-05
+ 1.8 2.539955357142857e-05 0.0 2.5404017857142854e-05 0.0 2.540457589285714e-05 1.8
+ 2.5416852678571426e-05 1.8 2.5417410714285712e-05 0.0 2.5421875e-05 0.0 2.5422433035714283e-05 1.8 2.543470982142857e-05
+ 1.8 2.5435267857142855e-05 0.0 2.5439732142857142e-05 0.0 2.5440290178571425e-05 1.8
+ 2.5452566964285714e-05 1.8 2.5453124999999997e-05 0.0 2.5457589285714284e-05 0.0 2.545814732142857e-05 1.8
+ 2.5470424107142856e-05 1.8 2.5470982142857143e-05 0.0 2.5475446428571427e-05 0.0 2.5476004464285713e-05 1.8
+ 2.5488281249999998e-05 1.8 2.5488839285714285e-05 0.0 2.549330357142857e-05 0.0 2.5493861607142856e-05 1.8
+ 2.550613839285714e-05 1.8 2.5506696428571427e-05 0.0 2.551116071428571e-05 0.0 2.5511718749999998e-05 1.8
+ 2.5523995535714283e-05 1.8 2.552455357142857e-05 0.0 2.5529017857142857e-05 0.0 2.552957589285714e-05 1.8
+ 2.5541852678571425e-05 1.8 2.5542410714285712e-05 0.0 2.5546875e-05 0.0 2.5547433035714283e-05 1.8 2.555970982142857e-05
+ 1.8 2.5560267857142854e-05 0.0 2.556473214285714e-05 0.0 2.556529017857143e-05 1.8
+ 2.5577566964285713e-05 1.8 2.5578124999999997e-05 0.0 2.5582589285714284e-05 0.0 2.558314732142857e-05 1.8
+ 2.5595424107142856e-05 1.8 2.5595982142857142e-05 0.0 2.5600446428571426e-05 0.0 2.5601004464285713e-05 1.8
+ 2.5613281249999998e-05 1.8 2.5613839285714285e-05 0.0 2.561830357142857e-05 0.0 2.5618861607142855e-05 1.8
+ 2.563113839285714e-05 1.8 2.5631696428571427e-05 0.0 2.563616071428571e-05 0.0 2.5636718749999998e-05 1.8
+ 2.5648995535714283e-05 1.8 2.564955357142857e-05 0.0 2.5654017857142857e-05 0.0 2.565457589285714e-05 1.8
+ 2.5666852678571428e-05 1.8 2.566741071428571e-05 0.0 2.5671875e-05 0.0 2.5672433035714282e-05 1.8 2.568470982142857e-05
+ 1.8 2.5685267857142854e-05 0.0 2.568973214285714e-05 0.0 2.5690290178571428e-05 1.8
+ 2.5702566964285713e-05 1.8 2.5703125e-05 0.0 2.5707589285714284e-05 0.0 2.570814732142857e-05 1.8 2.5720424107142855e-05
+ 1.8 2.5720982142857142e-05 0.0 2.5725446428571426e-05 0.0 2.5726004464285713e-05 1.8
+ 2.5738281249999998e-05 1.8 2.5738839285714284e-05 0.0 2.5743303571428568e-05 0.0 2.5743861607142855e-05 1.8
+ 2.575613839285714e-05 1.8 2.5756696428571427e-05 0.0 2.5761160714285714e-05 0.0 2.5761718749999997e-05 1.8
+ 2.5773995535714282e-05 1.8 2.577455357142857e-05 0.0 2.5779017857142856e-05 0.0 2.577957589285714e-05 1.8
+ 2.5791852678571428e-05 1.8 2.579241071428571e-05 0.0 2.5796875e-05 0.0 2.5797433035714285e-05 1.8 2.580970982142857e-05
+ 1.8 2.5810267857142857e-05 0.0 2.581473214285714e-05 0.0 2.5815290178571428e-05 1.8
+ 2.5827566964285713e-05 1.8 2.5828125e-05 0.0 2.5832589285714283e-05 0.0 2.583314732142857e-05 1.8 2.5845424107142855e-05
+ 1.8 2.584598214285714e-05 0.0 2.5850446428571426e-05 0.0 2.5851004464285712e-05 1.8
+ 2.5863281249999997e-05 1.8 2.5863839285714284e-05 0.0 2.586830357142857e-05 0.0 2.5868861607142855e-05 1.8
+ 2.588113839285714e-05 1.8 2.5881696428571426e-05 0.0 2.5886160714285714e-05 0.0 2.5886718749999997e-05 1.8
+ 2.5898995535714285e-05 1.8 2.589955357142857e-05 0.0 2.5904017857142856e-05 0.0 2.5904575892857143e-05 1.8
+ 2.5916852678571428e-05 1.8 2.591741071428571e-05 0.0 2.5921874999999998e-05 0.0 2.5922433035714285e-05 1.8
+ 2.593470982142857e-05 1.8 2.5935267857142857e-05 0.0 2.593973214285714e-05 0.0 2.5940290178571427e-05 1.8
+ 2.5952566964285712e-05 1.8 2.5953125e-05 0.0 2.5957589285714283e-05 0.0 2.595814732142857e-05 1.8 2.5970424107142855e-05
+ 1.8 2.597098214285714e-05 0.0 2.5975446428571425e-05 0.0 2.5976004464285712e-05 1.8
+ 2.5988281249999997e-05 1.8 2.5988839285714284e-05 0.0 2.599330357142857e-05 0.0 2.5993861607142854e-05 1.8
+ 2.6006138392857143e-05 1.8 2.6006696428571426e-05 0.0 2.6011160714285713e-05 0.0 2.6011718749999997e-05 1.8
+ 2.6023995535714285e-05 1.8 2.6024553571428568e-05 0.0 2.6029017857142856e-05 0.0 2.6029575892857142e-05 1.8
+ 2.6041852678571427e-05 1.8 2.6042410714285714e-05 0.0 2.6046874999999998e-05 0.0 2.6047433035714285e-05 1.8
+ 2.605970982142857e-05 1.8 2.6060267857142856e-05 0.0 2.606473214285714e-05 0.0 2.6065290178571427e-05 1.8
+ 2.6077566964285712e-05 1.8 2.6078125e-05 0.0 2.6082589285714282e-05 0.0 2.608314732142857e-05 1.8 2.6095424107142854e-05
+ 1.8 2.609598214285714e-05 0.0 2.6100446428571428e-05 0.0 2.610100446428571e-05 1.8
+ 2.6113281249999996e-05 1.8 2.6113839285714283e-05 0.0 2.611830357142857e-05 0.0 2.6118861607142854e-05 1.8
+ 2.6131138392857142e-05 1.8 2.6131696428571426e-05 0.0 2.6136160714285713e-05 0.0 2.613671875e-05 1.8
+ 2.6148995535714285e-05 1.8 2.6149553571428568e-05 0.0 2.6154017857142855e-05 0.0 2.6154575892857142e-05 1.8
+ 2.6166852678571427e-05 1.8 2.6167410714285714e-05 0.0 2.6171874999999997e-05 0.0 2.6172433035714284e-05 1.8
+ 2.618470982142857e-05 1.8 2.6185267857142856e-05 0.0 2.618973214285714e-05 0.0 2.6190290178571427e-05 1.8
+ 2.620256696428571e-05 1.8 2.6203124999999998e-05 0.0 2.6207589285714282e-05 0.0 2.620814732142857e-05 1.8
+ 2.6220424107142854e-05 1.8 2.622098214285714e-05 0.0 2.6225446428571428e-05 0.0 2.622600446428571e-05 1.8 2.623828125e-05
+ 1.8 2.6238839285714283e-05 0.0 2.624330357142857e-05 0.0 2.6243861607142857e-05 1.8
+ 2.6256138392857142e-05 1.8 2.6256696428571425e-05 0.0 2.6261160714285712e-05 0.0 2.626171875e-05 1.8
+ 2.6273995535714284e-05 1.8 2.627455357142857e-05 0.0 2.6279017857142855e-05 0.0 2.627957589285714e-05 1.8
+ 2.6291852678571427e-05 1.8 2.6292410714285713e-05 0.0 2.6296874999999997e-05 0.0 2.6297433035714284e-05 1.8
+ 2.630970982142857e-05 1.8 2.6310267857142856e-05 0.0 2.631473214285714e-05 0.0 2.6315290178571426e-05 1.8
+ 2.632756696428571e-05 1.8 2.6328124999999998e-05 0.0 2.6332589285714285e-05 0.0 2.633314732142857e-05 1.8
+ 2.6345424107142857e-05 1.8 2.634598214285714e-05 0.0 2.6350446428571428e-05 0.0 2.635100446428571e-05 1.8 2.636328125e-05
+ 1.8 2.6363839285714283e-05 0.0 2.636830357142857e-05 0.0 2.6368861607142857e-05 1.8
+ 2.638113839285714e-05 1.8 2.6381696428571428e-05 0.0 2.6386160714285712e-05 0.0 2.638671875e-05 1.8
+ 2.6398995535714284e-05 1.8 2.639955357142857e-05 0.0 2.6404017857142854e-05 0.0 2.640457589285714e-05 1.8
+ 2.6416852678571426e-05 1.8 2.6417410714285713e-05 0.0 2.6421874999999997e-05 0.0 2.6422433035714284e-05 1.8
+ 2.643470982142857e-05 1.8 2.6435267857142855e-05 0.0 2.6439732142857143e-05 0.0 2.6440290178571426e-05 1.8
+ 2.645256696428571e-05 1.8 2.6453124999999998e-05 0.0 2.6457589285714285e-05 0.0 2.6458147321428568e-05 1.8
+ 2.6470424107142857e-05 1.8 2.647098214285714e-05 0.0 2.6475446428571427e-05 0.0 2.6476004464285714e-05 1.8 2.648828125e-05
+ 1.8 2.6488839285714282e-05 0.0 2.649330357142857e-05 0.0 2.6493861607142856e-05 1.8
+ 2.650613839285714e-05 1.8 2.6506696428571428e-05 0.0 2.6511160714285712e-05 0.0 2.651171875e-05 1.8
+ 2.6523995535714283e-05 1.8 2.652455357142857e-05 0.0 2.6529017857142854e-05 0.0 2.652957589285714e-05 1.8
+ 2.6541852678571426e-05 1.8 2.6542410714285713e-05 0.0 2.6546874999999996e-05 0.0 2.6547433035714283e-05 1.8
+ 2.6559709821428568e-05 1.8 2.6560267857142855e-05 0.0 2.6564732142857142e-05 0.0 2.6565290178571426e-05 1.8
+ 2.6577566964285714e-05 1.8 2.6578124999999997e-05 0.0 2.6582589285714284e-05 0.0 2.6583147321428568e-05 1.8
+ 2.6595424107142856e-05 1.8 2.659598214285714e-05 0.0 2.6600446428571427e-05 0.0 2.6601004464285714e-05 1.8 2.661328125e-05
+ 1.8 2.6613839285714285e-05 0.0 2.661830357142857e-05 0.0 2.6618861607142856e-05 1.8
+ 2.663113839285714e-05 1.8 2.6631696428571428e-05 0.0 2.663616071428571e-05 0.0 2.6636718749999998e-05 1.8
+ 2.6648995535714283e-05 1.8 2.664955357142857e-05 0.0 2.6654017857142854e-05 0.0 2.665457589285714e-05 1.8
+ 2.6666852678571425e-05 1.8 2.6667410714285712e-05 0.0 2.6671875e-05 0.0 2.6672433035714283e-05 1.8 2.668470982142857e-05
+ 1.8 2.6685267857142855e-05 0.0 2.6689732142857142e-05 0.0 2.6690290178571425e-05 1.8
+ 2.6702566964285713e-05 1.8 2.6703124999999997e-05 0.0 2.6707589285714284e-05 0.0 2.670814732142857e-05 1.8
+ 2.6720424107142856e-05 1.8 2.6720982142857143e-05 0.0 2.6725446428571426e-05 0.0 2.6726004464285713e-05 1.8
+ 2.6738281249999998e-05 1.8 2.6738839285714285e-05 0.0 2.674330357142857e-05 0.0 2.6743861607142856e-05 1.8
+ 2.675613839285714e-05 1.8 2.6756696428571427e-05 0.0 2.676116071428571e-05 0.0 2.6761718749999998e-05 1.8
+ 2.6773995535714283e-05 1.8 2.677455357142857e-05 0.0 2.6779017857142857e-05 0.0 2.677957589285714e-05 1.8
+ 2.6791852678571425e-05 1.8 2.6792410714285712e-05 0.0 2.6796875e-05 0.0 2.6797433035714283e-05 1.8 2.680970982142857e-05
+ 1.8 2.6810267857142854e-05 0.0 2.681473214285714e-05 0.0 2.6815290178571428e-05 1.8
+ 2.6827566964285713e-05 1.8 2.6828124999999997e-05 0.0 2.6832589285714284e-05 0.0 2.683314732142857e-05 1.8
+ 2.6845424107142855e-05 1.8 2.6845982142857142e-05 0.0 2.6850446428571426e-05 0.0 2.6851004464285713e-05 1.8
+ 2.6863281249999998e-05 1.8 2.6863839285714285e-05 0.0 2.686830357142857e-05 0.0 2.6868861607142855e-05 1.8
+ 2.688113839285714e-05 1.8 2.6881696428571427e-05 0.0 2.688616071428571e-05 0.0 2.6886718749999998e-05 1.8
+ 2.6898995535714282e-05 1.8 2.689955357142857e-05 0.0 2.6904017857142856e-05 0.0 2.690457589285714e-05 1.8
+ 2.6916852678571428e-05 1.8 2.691741071428571e-05 0.0 2.6922433035714282e-05 0.0 2.692299107142857e-05 1.8
+ 2.6934151785714284e-05 1.8 2.693470982142857e-05 0.0 2.6940290178571428e-05 0.0 2.694084821428571e-05 1.8
+ 2.6952008928571426e-05 1.8 2.6952566964285713e-05 0.0 2.695814732142857e-05 0.0 2.6958705357142854e-05 1.8
+ 2.696986607142857e-05 1.8 2.6970424107142855e-05 0.0 2.6976004464285713e-05 0.0 2.69765625e-05 1.8 2.698772321428571e-05
+ 1.8 2.6988281249999997e-05 0.0 2.6993861607142855e-05 0.0 2.699441964285714e-05 1.8
+ 2.7005580357142856e-05 1.8 2.700613839285714e-05 0.0 2.7011718749999997e-05 0.0 2.7012276785714284e-05 1.8 2.70234375e-05
+ 1.8 2.7023995535714285e-05 0.0 2.702957589285714e-05 0.0 2.7030133928571426e-05 1.8
+ 2.704129464285714e-05 1.8 2.7041852678571428e-05 0.0 2.7047433035714285e-05 0.0 2.704799107142857e-05 1.8
+ 2.7059151785714283e-05 1.8 2.705970982142857e-05 0.0 2.7065290178571428e-05 0.0 2.706584821428571e-05 1.8
+ 2.7077008928571426e-05 1.8 2.7077566964285712e-05 0.0 2.708314732142857e-05 0.0 2.7083705357142857e-05 1.8
+ 2.7094866071428568e-05 1.8 2.7095424107142855e-05 0.0 2.7101004464285712e-05 0.0 2.71015625e-05 1.8 2.7112723214285714e-05
+ 1.8 2.7113281249999997e-05 0.0 2.7118861607142854e-05 0.0 2.711941964285714e-05 1.8
+ 2.7130580357142856e-05 1.8 2.713113839285714e-05 0.0 2.7136718749999997e-05 0.0 2.7137276785714284e-05 1.8 2.71484375e-05
+ 1.8 2.7148995535714285e-05 0.0 2.7154575892857143e-05 0.0 2.7155133928571426e-05 1.8
+ 2.716629464285714e-05 1.8 2.7166852678571427e-05 0.0 2.7172433035714285e-05 0.0 2.7172991071428568e-05 1.8
+ 2.7184151785714283e-05 1.8 2.718470982142857e-05 0.0 2.7190290178571427e-05 0.0 2.7190848214285714e-05 1.8
+ 2.7202008928571425e-05 1.8 2.7202566964285712e-05 0.0 2.720814732142857e-05 0.0 2.7208705357142856e-05 1.8
+ 2.721986607142857e-05 1.8 2.7220424107142854e-05 0.0 2.7226004464285712e-05 0.0 2.72265625e-05 1.8 2.7237723214285713e-05
+ 1.8 2.7238281249999997e-05 0.0 2.7243861607142854e-05 0.0 2.724441964285714e-05 1.8
+ 2.7255580357142856e-05 1.8 2.7256138392857142e-05 0.0 2.7261718749999996e-05 0.0 2.7262276785714283e-05 1.8
+ 2.7273437499999998e-05 1.8 2.7273995535714285e-05 0.0 2.7279575892857142e-05 0.0 2.7280133928571426e-05 1.8
+ 2.729129464285714e-05 1.8 2.7291852678571427e-05 0.0 2.7297433035714284e-05 0.0 2.7297991071428568e-05 1.8
+ 2.7309151785714283e-05 1.8 2.730970982142857e-05 0.0 2.7315290178571427e-05 0.0 2.7315848214285714e-05 1.8
+ 2.7327008928571425e-05 1.8 2.7327566964285712e-05 0.0 2.7333705357142856e-05 0.0 2.733426339285714e-05 1.8
+ 2.7344308035714284e-05 1.8 2.734486607142857e-05 0.0 2.7351562499999998e-05 0.0 2.7352120535714285e-05 1.8
+ 2.7362165178571426e-05 1.8 2.7362723214285713e-05 0.0 2.736941964285714e-05 0.0 2.7369977678571427e-05 1.8
+ 2.738002232142857e-05 1.8 2.7380580357142855e-05 0.0 2.7387276785714283e-05 0.0 2.738783482142857e-05 1.8
+ 2.739787946428571e-05 1.8 2.7398437499999998e-05 0.0 2.7405133928571425e-05 0.0 2.7405691964285712e-05 1.8
+ 2.7415736607142857e-05 1.8 2.741629464285714e-05 0.0 2.742299107142857e-05 0.0 2.7423549107142854e-05 1.8 2.743359375e-05
+ 1.8 2.7434151785714282e-05 0.0 2.7440848214285713e-05 0.0 2.7441406249999997e-05 1.8
+ 2.745145089285714e-05 1.8 2.7452008928571428e-05 0.0 2.7458705357142856e-05 0.0 2.7459263392857142e-05 1.8
+ 2.7469308035714284e-05 1.8 2.746986607142857e-05 0.0 2.7476562499999998e-05 0.0 2.7477120535714285e-05 1.8
+ 2.7487165178571426e-05 1.8 2.7487723214285713e-05 0.0 2.749441964285714e-05 0.0 2.7494977678571427e-05 1.8
+ 2.7505022321428568e-05 1.8 2.7505580357142855e-05 0.0 2.7512276785714283e-05 0.0 2.751283482142857e-05 1.8
+ 2.7522879464285714e-05 1.8 2.7523437499999997e-05 0.0 2.7530133928571428e-05 0.0 2.753069196428571e-05 1.8
+ 2.7540736607142856e-05 1.8 2.754129464285714e-05 0.0 2.754799107142857e-05 0.0 2.7548549107142854e-05 1.8 2.755859375e-05
+ 1.8 2.7559151785714285e-05 0.0 2.7565848214285713e-05 0.0 2.756640625e-05 1.8 2.757645089285714e-05 1.8
+ 2.7577008928571428e-05 0.0 2.7583705357142855e-05 0.0 2.7584263392857142e-05 1.8 2.7594308035714283e-05 1.8
+ 2.759486607142857e-05 0.0 2.7601562499999998e-05 0.0 2.7602120535714284e-05 1.8 2.7612165178571426e-05 1.8
+ 2.7612723214285712e-05 0.0 2.761941964285714e-05 0.0 2.7619977678571427e-05 1.8 2.7630022321428568e-05 1.8
+ 2.7630580357142855e-05 0.0 2.7637276785714282e-05 0.0 2.763783482142857e-05 1.8 2.7647879464285714e-05 1.8
+ 2.7648437499999997e-05 0.0 2.7655133928571428e-05 0.0 2.765569196428571e-05 1.8 2.7665736607142856e-05 1.8
+ 2.766629464285714e-05 0.0 2.767299107142857e-05 0.0 2.7673549107142854e-05 1.8 2.768303571428571e-05 1.8
+ 2.7683593749999998e-05 0.0 2.769140625e-05 0.0 2.7691964285714283e-05 1.8 2.7700892857142854e-05 1.8 2.770145089285714e-05
+ 0.0 2.770926339285714e-05 0.0 2.7709821428571425e-05 1.8 2.771875e-05 1.8 2.7719308035714283e-05 0.0
+ 2.7727120535714284e-05 0.0 2.772767857142857e-05 1.8 2.7736607142857142e-05 1.8 2.7737165178571425e-05 0.0
+ 2.7744977678571426e-05 0.0 2.7745535714285713e-05 1.8 2.7754464285714284e-05 1.8 2.775502232142857e-05 0.0
+ 2.776283482142857e-05 0.0 2.7763392857142855e-05 1.8 2.7772321428571426e-05 1.8 2.7772879464285713e-05 0.0
+ 2.778069196428571e-05 0.0 2.7781249999999998e-05 1.8 2.779017857142857e-05 1.8 2.7790736607142856e-05 0.0
+ 2.7798549107142857e-05 0.0 2.779910714285714e-05 1.8 2.780803571428571e-05 1.8 2.7808593749999998e-05 0.0 2.781640625e-05
+ 0.0 2.7816964285714282e-05 1.8 2.7825892857142853e-05 1.8 2.782645089285714e-05 0.0
+ 2.783426339285714e-05 0.0 2.7834821428571428e-05 1.8 2.784375e-05 1.8 2.7844308035714283e-05 0.0 2.7852120535714284e-05
+ 0.0 2.785267857142857e-05 1.8 2.786160714285714e-05 1.8 2.7862165178571428e-05 0.0
+ 2.7869977678571426e-05 0.0 2.7870535714285713e-05 1.8 2.7879464285714284e-05 1.8 2.788002232142857e-05 0.0
+ 2.7887834821428568e-05 0.0 2.7888392857142855e-05 1.8 2.7897321428571426e-05 1.8 2.7897879464285713e-05 0.0
+ 2.7905691964285714e-05 0.0 2.7906249999999997e-05 1.8 2.791517857142857e-05 1.8 2.7915736607142855e-05 0.0
+ 2.7923549107142856e-05 0.0 2.792410714285714e-05 1.8 2.793303571428571e-05 1.8 2.7933593749999998e-05 0.0 2.794140625e-05
+ 0.0 2.7941964285714285e-05 1.8 2.7950892857142856e-05 1.8 2.795145089285714e-05 0.0
+ 2.795926339285714e-05 0.0 2.7959821428571428e-05 1.8 2.796875e-05 1.8 2.7969308035714282e-05 0.0 2.7977120535714283e-05
+ 0.0 2.797767857142857e-05 1.8 2.798660714285714e-05 1.8 2.7987165178571428e-05 0.0
+ 2.7994977678571426e-05 0.0 2.7995535714285712e-05 1.8 2.8003906249999997e-05 1.8 2.8004464285714283e-05 0.0
+ 2.8013392857142855e-05 0.0 2.801395089285714e-05 1.8 2.8021763392857142e-05 1.8 2.8022321428571426e-05 0.0
+ 2.8031249999999997e-05 0.0 2.8031808035714284e-05 1.8 2.8039620535714285e-05 1.8 2.8040178571428568e-05 0.0
+ 2.804910714285714e-05 0.0 2.8049665178571426e-05 1.8 2.8057477678571427e-05 1.8 2.8058035714285714e-05 0.0
+ 2.8066964285714285e-05 0.0 2.806752232142857e-05 1.8 2.807533482142857e-05 1.8 2.8075892857142856e-05 0.0
+ 2.8084821428571427e-05 0.0 2.808537946428571e-05 1.8 2.8093191964285712e-05 1.8 2.809375e-05 0.0 2.810267857142857e-05 0.0
+ 2.8103236607142856e-05 1.8 2.8111049107142854e-05 1.8 2.811160714285714e-05 0.0 2.8120535714285712e-05 0.0 2.812109375e-05
+ 1.8 2.8128906249999996e-05 1.8 2.8129464285714283e-05 0.0 2.8138392857142854e-05 0.0
+ 2.813895089285714e-05 1.8 2.8146763392857142e-05 1.8 2.8147321428571425e-05 0.0 2.8156249999999997e-05 0.0
+ 2.8156808035714283e-05 1.8 2.8164620535714284e-05 1.8 2.8165178571428568e-05 0.0 2.8174107142857142e-05 0.0
+ 2.8174665178571426e-05 1.8 2.8182477678571427e-05 1.8 2.8183035714285713e-05 0.0 2.8191964285714285e-05 0.0
+ 2.8192522321428568e-05 1.8 2.820033482142857e-05 1.8 2.8200892857142856e-05 0.0 2.8209821428571427e-05 0.0
+ 2.8210379464285714e-05 1.8 2.821819196428571e-05 1.8 2.8218749999999998e-05 0.0 2.822767857142857e-05 0.0
+ 2.8228236607142856e-05 1.8 2.8236049107142854e-05 1.8 2.823660714285714e-05 0.0 2.824553571428571e-05 0.0 2.824609375e-05
+ 1.8 2.825390625e-05 1.8 2.8254464285714283e-05 0.0 2.8263392857142854e-05 0.0 2.826395089285714e-05 1.8
+ 2.8271763392857142e-05 1.8 2.8272321428571425e-05 0.0 2.828125e-05 0.0 2.8281808035714283e-05 1.8 2.8289620535714284e-05
+ 1.8 2.829017857142857e-05 0.0 2.8299107142857142e-05 0.0 2.8299665178571425e-05 1.8
+ 2.8307477678571426e-05 1.8 2.8308035714285713e-05 0.0 2.8316964285714284e-05 0.0 2.831752232142857e-05 1.8
+ 2.8324776785714285e-05 1.8 2.832533482142857e-05 0.0 2.8335379464285713e-05 0.0 2.8335937499999997e-05 1.8
+ 2.8342633928571428e-05 1.8 2.834319196428571e-05 0.0 2.8353236607142856e-05 0.0 2.8353794642857142e-05 1.8
+ 2.836049107142857e-05 1.8 2.8361049107142857e-05 0.0 2.8371093749999998e-05 0.0 2.8371651785714285e-05 1.8
+ 2.8378348214285712e-05 1.8 2.837890625e-05 0.0 2.838895089285714e-05 0.0 2.8389508928571427e-05 1.8 2.8396205357142855e-05
+ 1.8 2.839676339285714e-05 0.0 2.8406808035714283e-05 0.0 2.840736607142857e-05 1.8
+ 2.8414062499999997e-05 1.8 2.8414620535714284e-05 0.0 2.8424665178571425e-05 0.0 2.8425223214285712e-05 1.8
+ 2.843191964285714e-05 1.8 2.8432477678571426e-05 0.0 2.844252232142857e-05 0.0 2.8443080357142854e-05 1.8
+ 2.8449776785714285e-05 1.8 2.845033482142857e-05 0.0 2.8460379464285713e-05 0.0 2.8460937499999996e-05 1.8
+ 2.8467633928571427e-05 1.8 2.846819196428571e-05 0.0 2.8478236607142855e-05 0.0 2.8478794642857142e-05 1.8
+ 2.848549107142857e-05 1.8 2.8486049107142856e-05 0.0 2.8496093749999998e-05 0.0 2.8496651785714284e-05 1.8
+ 2.8503348214285712e-05 1.8 2.850390625e-05 0.0 2.851395089285714e-05 0.0 2.8514508928571427e-05 1.8 2.8521205357142854e-05
+ 1.8 2.852176339285714e-05 0.0 2.8531808035714282e-05 0.0 2.853236607142857e-05 1.8
+ 2.8539062499999997e-05 1.8 2.8539620535714283e-05 0.0 2.8549665178571428e-05 0.0 2.855022321428571e-05 1.8
+ 2.8556919642857142e-05 1.8 2.8557477678571426e-05 0.0 2.856752232142857e-05 0.0 2.8568080357142854e-05 1.8
+ 2.8574776785714285e-05 1.8 2.8575334821428568e-05 0.0 2.8585379464285713e-05 0.0 2.85859375e-05 1.8 2.8592633928571427e-05
+ 1.8 2.8593191964285714e-05 0.0 2.8603236607142855e-05 0.0 2.8603794642857142e-05 1.8
+ 2.861049107142857e-05 1.8 2.8611049107142856e-05 0.0 2.8621093749999997e-05 0.0 2.8621651785714284e-05 1.8
+ 2.862834821428571e-05 1.8 2.862890625e-05 0.0 2.863895089285714e-05 0.0 2.8639508928571426e-05 1.8 2.8646205357142854e-05
+ 1.8 2.864676339285714e-05 0.0 2.8656808035714285e-05 0.0 2.865736607142857e-05 1.8 2.86640625e-05 1.8
+ 2.8664620535714283e-05 0.0 2.867522321428571e-05 0.0 2.8675781249999998e-05 1.8 2.8681361607142855e-05 1.8
+ 2.8681919642857142e-05 0.0 2.8693080357142857e-05 0.0 2.869363839285714e-05 1.8 2.8699218749999998e-05 1.8
+ 2.8699776785714284e-05 0.0 2.87109375e-05 0.0 2.8711495535714282e-05 1.8 2.871707589285714e-05 1.8 2.8717633928571427e-05
+ 0.0 2.872879464285714e-05 0.0 2.8729352678571428e-05 1.8 2.8734933035714282e-05 1.8
+ 2.873549107142857e-05 0.0 2.8746651785714284e-05 0.0 2.874720982142857e-05 1.8 2.8752790178571428e-05 1.8
+ 2.875334821428571e-05 0.0 2.8764508928571426e-05 0.0 2.8765066964285713e-05 1.8 2.877064732142857e-05 1.8
+ 2.8771205357142854e-05 0.0 2.878236607142857e-05 0.0 2.8782924107142855e-05 1.8 2.8788504464285713e-05 1.8 2.87890625e-05
+ 0.0 2.880022321428571e-05 0.0 2.8800781249999997e-05 1.8 2.8806361607142855e-05 1.8
+ 2.880691964285714e-05 0.0 2.8818080357142856e-05 0.0 2.881863839285714e-05 1.8 2.8824218749999997e-05 1.8
+ 2.8824776785714284e-05 0.0 2.88359375e-05 0.0 2.8836495535714282e-05 1.8 2.884207589285714e-05 1.8 2.8842633928571426e-05
+ 0.0 2.885379464285714e-05 0.0 2.8854352678571428e-05 1.8 2.8859933035714285e-05 1.8
+ 2.886049107142857e-05 0.0 2.8871651785714283e-05 0.0 2.887220982142857e-05 1.8 2.8877790178571428e-05 1.8
+ 2.887834821428571e-05 0.0 2.8889508928571426e-05 0.0 2.8890066964285712e-05 1.8 2.889564732142857e-05 1.8
+ 2.8896205357142857e-05 0.0 2.8907366071428568e-05 0.0 2.8907924107142855e-05 1.8 2.8913504464285712e-05 1.8 2.89140625e-05
+ 0.0 2.8925223214285714e-05 0.0 2.8925781249999997e-05 1.8 2.8931361607142854e-05 1.8
+ 2.893191964285714e-05 0.0 2.8943080357142856e-05 0.0 2.894363839285714e-05 1.8 2.8949218749999997e-05 1.8
+ 2.8949776785714284e-05 0.0 2.89609375e-05 0.0 2.8961495535714285e-05 1.8 2.896707589285714e-05 1.8 2.8967633928571426e-05
+ 0.0 2.897879464285714e-05 0.0 2.8979352678571427e-05 1.8 2.8984933035714285e-05 1.8
+ 2.8985491071428568e-05 0.0 2.8996651785714283e-05 0.0 2.899720982142857e-05 1.8 2.9002790178571427e-05 1.8
+ 2.900334821428571e-05 0.0 2.9014508928571425e-05 0.0 2.9015066964285712e-05 1.8 2.902064732142857e-05 1.8
+ 2.9021205357142856e-05 0.0 2.9032366071428568e-05 0.0 2.9032924107142854e-05 1.8 2.9038504464285712e-05 1.8 2.90390625e-05
+ 0.0 2.9050223214285713e-05 0.0 2.9050781249999997e-05 1.8 2.9056361607142854e-05 1.8
+ 2.905691964285714e-05 0.0 2.9068080357142856e-05 0.0 2.9068638392857142e-05 1.8 2.9074218749999996e-05 1.8
+ 2.9074776785714283e-05 0.0 2.9086495535714285e-05 0.0 2.9087053571428568e-05 1.8 2.9091517857142855e-05 1.8
+ 2.9092075892857142e-05 0.0 2.9104352678571427e-05 0.0 2.9104910714285714e-05 1.8 2.9109374999999998e-05 1.8
+ 2.9109933035714285e-05 0.0 2.912220982142857e-05 0.0 2.9122767857142856e-05 1.8 2.912723214285714e-05 1.8
+ 2.9127790178571427e-05 0.0 2.9140066964285712e-05 0.0 2.9140625e-05 1.8 2.9145089285714282e-05 1.8 2.914564732142857e-05
+ 0.0 2.9157924107142854e-05 0.0 2.915848214285714e-05 1.8 2.9162946428571428e-05 1.8
+ 2.916350446428571e-05 0.0 2.9175781249999996e-05 0.0 2.9176339285714283e-05 1.8 2.918080357142857e-05 1.8
+ 2.9181361607142854e-05 0.0 2.9193638392857142e-05 0.0 2.9194196428571425e-05 1.8 2.9198660714285713e-05 1.8
+ 2.919921875e-05 0.0 2.9211495535714284e-05 0.0 2.9212053571428568e-05 1.8 2.9216517857142855e-05 1.8
+ 2.9217075892857142e-05 0.0 2.9229352678571427e-05 0.0 2.9229910714285714e-05 1.8 2.9234374999999997e-05 1.8
+ 2.9234933035714284e-05 0.0 2.924720982142857e-05 0.0 2.9247767857142856e-05 1.8 2.925223214285714e-05 1.8
+ 2.9252790178571426e-05 0.0 2.926506696428571e-05 0.0 2.9265624999999998e-05 1.8 2.9270089285714282e-05 1.8
+ 2.927064732142857e-05 0.0 2.9282924107142854e-05 0.0 2.928348214285714e-05 1.8 2.9287946428571428e-05 1.8
+ 2.928850446428571e-05 0.0 2.930078125e-05 0.0 2.9301339285714283e-05 1.8 2.930580357142857e-05 1.8 2.9306361607142853e-05
+ 0.0 2.9318638392857142e-05 0.0 2.9319196428571425e-05 1.8 2.9323660714285712e-05 1.8 2.932421875e-05
+ 0.0 2.9336495535714284e-05 0.0 2.933705357142857e-05 1.8 2.9341517857142855e-05 1.8
+ 2.934207589285714e-05 0.0 2.9354352678571426e-05 0.0 2.9354910714285713e-05 1.8 2.9359374999999997e-05 1.8
+ 2.9359933035714284e-05 0.0 2.937220982142857e-05 0.0 2.9372767857142855e-05 1.8 2.937723214285714e-05 1.8
+ 2.9377790178571426e-05 0.0 2.939006696428571e-05 0.0 2.9390624999999998e-05 1.8 2.9395089285714285e-05 1.8
+ 2.939564732142857e-05 0.0 2.9407924107142853e-05 0.0 2.940848214285714e-05 1.8 2.9412946428571427e-05 1.8
+ 2.941350446428571e-05 0.0 2.942578125e-05 0.0 2.9426339285714282e-05 1.8 2.943080357142857e-05 1.8 2.9431361607142856e-05
+ 0.0 2.944363839285714e-05 0.0 2.9444196428571425e-05 1.8 2.9448660714285712e-05 1.8 2.944921875e-05 0.0
+ 2.9461495535714284e-05 0.0 2.946205357142857e-05 1.8 2.9466517857142854e-05 1.8 2.946707589285714e-05 0.0
+ 2.9479352678571426e-05 0.0 2.9479910714285713e-05 1.8 2.9484374999999997e-05 1.8 2.9484933035714283e-05 0.0
+ 2.949720982142857e-05 0.0 2.9497767857142855e-05 1.8 2.9502232142857142e-05 1.8 2.9502790178571426e-05 0.0
+ 2.951506696428571e-05 0.0 2.9515624999999997e-05 1.8 2.9520089285714285e-05 1.8 2.9520647321428568e-05 0.0
+ 2.9532924107142856e-05 0.0 2.953348214285714e-05 1.8 2.9537946428571427e-05 1.8 2.9538504464285714e-05 0.0 2.955078125e-05
+ 0.0 2.9551339285714282e-05 1.8 2.955580357142857e-05 1.8 2.9556361607142856e-05 0.0
+ 2.956863839285714e-05 0.0 2.9569196428571428e-05 1.8 2.9573660714285712e-05 1.8 2.957421875e-05 0.0
+ 2.9586495535714283e-05 0.0 2.958705357142857e-05 1.8 2.9591517857142854e-05 1.8 2.959207589285714e-05 0.0
+ 2.9604352678571426e-05 0.0 2.9604910714285712e-05 1.8 2.9609374999999996e-05 1.8 2.9609933035714283e-05 0.0
+ 2.9622209821428568e-05 0.0 2.9622767857142855e-05 1.8 2.9627232142857142e-05 1.8 2.9627790178571425e-05 0.0
+ 2.9640066964285714e-05 0.0 2.9640624999999997e-05 1.8 2.9645089285714284e-05 1.8 2.9645647321428568e-05 0.0
+ 2.9657924107142856e-05 0.0 2.965848214285714e-05 1.8 2.9662946428571427e-05 1.8 2.9663504464285713e-05 0.0 2.967578125e-05
+ 0.0 2.9676339285714285e-05 1.8 2.968080357142857e-05 1.8 2.9681361607142856e-05 0.0
+ 2.969363839285714e-05 0.0 2.9694196428571427e-05 1.8 2.969866071428571e-05 1.8 2.9699218749999998e-05 0.0
+ 2.9711495535714283e-05 0.0 2.971205357142857e-05 1.8 2.9716517857142854e-05 1.8 2.971707589285714e-05 0.0
+ 2.9729352678571425e-05 0.0 2.9729910714285712e-05 1.8 2.9734375e-05 1.8 2.9734933035714283e-05 0.0 2.9747209821428568e-05
+ 0.0 2.9747767857142854e-05 1.8 2.9752232142857142e-05 1.8 2.9752790178571425e-05 0.0
+ 2.9765066964285713e-05 0.0 2.9765624999999997e-05 1.8 2.9770089285714284e-05 1.8 2.977064732142857e-05 0.0
+ 2.9782924107142856e-05 0.0 2.978348214285714e-05 1.8 2.9787946428571426e-05 1.8 2.9788504464285713e-05 0.0
+ 2.9800781249999998e-05 0.0 2.9801339285714285e-05 1.8 2.980580357142857e-05 1.8 2.9806361607142855e-05 0.0
+ 2.981863839285714e-05 0.0 2.9819196428571427e-05 1.8 2.982366071428571e-05 1.8 2.9824218749999998e-05 0.0
+ 2.9836495535714283e-05 0.0 2.983705357142857e-05 1.8 2.9841517857142853e-05 1.8 2.984207589285714e-05 0.0
+ 2.9854352678571425e-05 0.0 2.9854910714285712e-05 1.8 2.9859375e-05 1.8 2.9859933035714282e-05 0.0 2.987220982142857e-05
+ 0.0 2.9872767857142854e-05 1.8 2.987723214285714e-05 1.8 2.9877790178571428e-05 0.0
+ 2.9890066964285713e-05 0.0 2.9890624999999996e-05 1.8 2.9895089285714284e-05 1.8 2.989564732142857e-05 0.0
+ 2.9907924107142855e-05 0.0 2.9908482142857142e-05 1.8 2.9912946428571426e-05 1.8 2.9913504464285713e-05 0.0
+ 2.9925781249999998e-05 0.0 2.9926339285714284e-05 1.8 2.993080357142857e-05 1.8 2.9931361607142855e-05 0.0
+ 2.994363839285714e-05 0.0 2.9944196428571427e-05 1.8 2.994866071428571e-05 1.8 2.9949218749999997e-05 0.0
+ 2.9961495535714282e-05 0.0 2.996205357142857e-05 1.8 2.9966517857142856e-05 1.8 2.996707589285714e-05 0.0
+ 2.9979352678571428e-05 0.0 2.997991071428571e-05 1.8 2.9984375e-05 1.8 2.9984933035714282e-05 0.0 2.999720982142857e-05
+ 0.0 2.9997767857142854e-05 1.8 3.000223214285714e-05 1.8 3.0002790178571428e-05 0.0
+ 3.0015066964285713e-05 0.0 3.0015625e-05 1.8 3.0020089285714283e-05 1.8 3.002064732142857e-05 0.0 3.0032924107142855e-05
+ 0.0 3.0033482142857142e-05 1.8 3.0037946428571426e-05 1.8 3.0038504464285712e-05 0.0
+ 3.0050781249999997e-05 0.0 3.0051339285714284e-05 1.8 3.0055803571428568e-05 1.8 3.0056361607142855e-05 0.0
+ 3.006863839285714e-05 0.0 3.0069196428571426e-05 1.8 3.0073660714285714e-05 1.8 3.0074218749999997e-05 0.0
+ 3.0086495535714282e-05 0.0 3.008705357142857e-05 1.8 3.0091517857142856e-05 1.8 3.009207589285714e-05 0.0
+ 3.0104352678571428e-05 0.0 3.010491071428571e-05 1.8 3.0109375e-05 1.8 3.0109933035714285e-05 0.0 3.012220982142857e-05
+ 0.0 3.0122767857142853e-05 1.8 3.012723214285714e-05 1.8 3.0127790178571427e-05 0.0
+ 3.0140066964285712e-05 0.0 3.0140625e-05 1.8 3.0145089285714283e-05 1.8 3.014564732142857e-05 0.0 3.0157924107142855e-05
+ 0.0 3.015848214285714e-05 1.8 3.0162946428571425e-05 1.8 3.0163504464285712e-05 0.0
+ 3.0175781249999997e-05 0.0 3.0176339285714284e-05 1.8 3.0180803571428568e-05 1.8 3.0181361607142854e-05 0.0
+ 3.019363839285714e-05 0.0 3.0194196428571426e-05 1.8 3.0198660714285713e-05 1.8 3.0199218749999997e-05 0.0
+ 3.0211495535714285e-05 0.0 3.021205357142857e-05 1.8 3.0216517857142856e-05 1.8 3.021707589285714e-05 0.0
+ 3.0229352678571427e-05 0.0 3.022991071428571e-05 1.8 3.0234374999999998e-05 1.8 3.0234933035714285e-05 0.0
+ 3.024720982142857e-05 0.0 3.0247767857142856e-05 1.8 3.025223214285714e-05 1.8 3.0252790178571427e-05 0.0
+ 3.0265066964285712e-05 0.0 3.0265625e-05 1.8 3.0270089285714283e-05 1.8 3.027064732142857e-05 0.0 3.0282924107142854e-05
+ 0.0 3.028348214285714e-05 1.8 3.0287946428571425e-05 1.8 3.0288504464285712e-05 0.0
+ 3.0300781249999997e-05 0.0 3.0301339285714283e-05 1.8 3.030580357142857e-05 1.8 3.0306361607142854e-05 0.0
+ 3.0318638392857142e-05 0.0 3.0319196428571426e-05 1.8 3.0323660714285713e-05 1.8 3.0324218749999996e-05 0.0
+ 3.0336495535714285e-05 0.0 3.0337053571428568e-05 1.8 3.0341517857142855e-05 1.8 3.0342075892857142e-05 0.0
+ 3.0354352678571427e-05 0.0 3.0354910714285714e-05 1.8 3.0359374999999998e-05 1.8 3.0359933035714284e-05 0.0
+ 3.037220982142857e-05 0.0 3.0372767857142856e-05 1.8 3.037723214285714e-05 1.8 3.0377790178571427e-05 0.0
+ 3.039006696428571e-05 0.0 3.0390625e-05 1.8 3.0395089285714282e-05 1.8 3.039564732142857e-05 0.0 3.0407924107142854e-05
+ 0.0 3.040848214285714e-05 1.8 3.0412946428571428e-05 1.8 3.041350446428571e-05 0.0
+ 3.0425781249999996e-05 0.0 3.0426339285714283e-05 1.8 3.043080357142857e-05 1.8 3.0431361607142854e-05 0.0
+ 3.0443638392857142e-05 0.0 3.0444196428571425e-05 1.8 3.0448660714285713e-05 1.8 3.044921875e-05 0.0
+ 3.0461495535714284e-05 0.0 3.0462053571428568e-05 1.8 3.0466517857142855e-05 1.8 3.0467075892857142e-05 0.0
+ 3.0479352678571427e-05 0.0 3.0479910714285713e-05 1.8 3.0484374999999997e-05 1.8 3.0484933035714284e-05 0.0
+ 3.049720982142857e-05 0.0 3.0497767857142856e-05 1.8 3.050223214285714e-05 1.8 3.0502790178571426e-05 0.0
+ 3.051506696428571e-05 0.0 3.0515624999999998e-05 1.8 3.0520089285714285e-05 1.8 3.052064732142857e-05 0.0
+ 3.053292410714286e-05 0.0 3.053348214285714e-05 1.8 3.053794642857143e-05 1.8 3.053850446428571e-05 0.0 3.055078125e-05
+ 0.0 3.055133928571428e-05 1.8 3.055580357142857e-05 1.8 3.055636160714285e-05 0.0 3.056863839285714e-05
+ 0.0 3.0569196428571425e-05 1.8 3.057366071428571e-05 1.8 3.0574218749999996e-05 0.0
+ 3.0586495535714284e-05 0.0 3.058705357142857e-05 1.8 3.0591517857142855e-05 1.8 3.059207589285714e-05 0.0
+ 3.0604352678571426e-05 0.0 3.060491071428571e-05 1.8 3.0609375e-05 1.8 3.060993303571428e-05 0.0 3.062220982142857e-05 0.0
+ 3.062276785714285e-05 1.8 3.062723214285714e-05 1.8 3.062779017857143e-05 0.0 3.064006696428571e-05 0.0 3.0640625e-05 1.8
+ 3.064508928571428e-05 1.8 3.064564732142857e-05 0.0 3.065792410714285e-05 0.0 3.0658482142857143e-05 1.8
+ 3.0662946428571424e-05 1.8 3.0663504464285714e-05 0.0 3.0675781249999996e-05 0.0 3.0676339285714286e-05 1.8
+ 3.0680803571428566e-05 1.8 3.0681361607142856e-05 0.0 3.069363839285714e-05 0.0 3.069419642857143e-05 1.8
+ 3.0698660714285715e-05 1.8 3.069921875e-05 0.0 3.071149553571428e-05 0.0 3.071205357142857e-05 1.8 3.071651785714286e-05
+ 1.8 3.071707589285714e-05 0.0 3.072935267857143e-05 0.0 3.072991071428571e-05 1.8 3.0734375e-05 1.8
+ 3.073493303571428e-05 0.0 3.074720982142857e-05 0.0 3.0747767857142855e-05 1.8 3.075223214285714e-05 1.8
+ 3.0752790178571426e-05 0.0 3.0765066964285714e-05 0.0 3.0765625e-05 1.8 3.0770089285714285e-05 1.8 3.077064732142857e-05
+ 0.0 3.0782924107142856e-05 0.0 3.078348214285714e-05 1.8 3.078794642857143e-05 1.8
+ 3.078850446428571e-05 0.0 3.080078125e-05 0.0 3.080133928571428e-05 1.8 3.080580357142857e-05 1.8 3.080636160714285e-05
+ 0.0 3.081863839285714e-05 0.0 3.0819196428571424e-05 1.8 3.082366071428571e-05 1.8
+ 3.0824218749999995e-05 0.0 3.083649553571428e-05 0.0 3.083705357142857e-05 1.8 3.0841517857142854e-05 1.8
+ 3.084207589285714e-05 0.0 3.0854352678571426e-05 0.0 3.085491071428571e-05 1.8 3.0859374999999996e-05 1.8
+ 3.0859933035714286e-05 0.0 3.087220982142857e-05 0.0 3.087276785714286e-05 1.8 3.087723214285714e-05 1.8
+ 3.087779017857143e-05 0.0 3.089006696428571e-05 0.0 3.0890625e-05 1.8 3.089508928571428e-05 1.8 3.089564732142857e-05 0.0
+ 3.090792410714285e-05 0.0 3.090848214285714e-05 1.8 3.091294642857142e-05 1.8 3.091350446428571e-05 0.0
+ 3.092522321428571e-05 0.0 3.0925781249999995e-05 1.8 3.0931361607142856e-05 1.8 3.093191964285714e-05 0.0
+ 3.0943080357142854e-05 0.0 3.0943638392857144e-05 1.8 3.094921875e-05 1.8 3.094977678571428e-05 0.0 3.0960937499999996e-05
+ 0.0 3.0961495535714286e-05 1.8 3.096707589285714e-05 1.8 3.0967633928571424e-05 0.0
+ 3.097879464285714e-05 0.0 3.097935267857143e-05 1.8 3.098493303571428e-05 1.8 3.0985491071428566e-05 0.0
+ 3.099665178571428e-05 0.0 3.099720982142857e-05 1.8 3.1002790178571425e-05 1.8 3.1003348214285715e-05 0.0
+ 3.101450892857142e-05 0.0 3.101506696428571e-05 1.8 3.102064732142857e-05 1.8 3.102120535714286e-05 0.0
+ 3.103236607142857e-05 0.0 3.1032924107142856e-05 1.8 3.103850446428571e-05 1.8 3.10390625e-05 0.0 3.1050223214285715e-05
+ 0.0 3.105078125e-05 1.8 3.105636160714285e-05 1.8 3.105691964285714e-05 0.0 3.106808035714286e-05 0.0
+ 3.106863839285714e-05 1.8 3.107421875e-05 1.8 3.1074776785714284e-05 0.0 3.10859375e-05 0.0 3.108649553571428e-05 1.8
+ 3.109207589285714e-05 1.8 3.109263392857143e-05 0.0 3.110379464285714e-05 0.0 3.1104352678571425e-05 1.8
+ 3.1109933035714286e-05 1.8 3.111049107142857e-05 0.0 3.1121651785714284e-05 0.0 3.112220982142857e-05 1.8
+ 3.112779017857143e-05 1.8 3.112834821428571e-05 0.0 3.1139508928571426e-05 0.0 3.114006696428571e-05 1.8
+ 3.114564732142857e-05 1.8 3.1146205357142854e-05 0.0 3.115736607142857e-05 0.0 3.115792410714285e-05 1.8
+ 3.116350446428571e-05 1.8 3.1164062499999996e-05 0.0 3.117522321428571e-05 0.0 3.117578125e-05 1.8 3.1181361607142855e-05
+ 1.8 3.118191964285714e-05 0.0 3.119308035714285e-05 0.0 3.119363839285714e-05 1.8 3.119921875e-05 1.8
+ 3.119977678571428e-05 0.0 3.1210937499999995e-05 0.0 3.1211495535714286e-05 1.8 3.121707589285714e-05 1.8
+ 3.121763392857142e-05 0.0 3.122879464285714e-05 0.0 3.122935267857143e-05 1.8 3.123493303571428e-05 1.8
+ 3.123549107142857e-05 0.0 3.124665178571428e-05 0.0 3.124720982142857e-05 1.8 3.1252790178571424e-05 1.8
+ 3.1253348214285714e-05 0.0 3.126450892857143e-05 0.0 3.126506696428571e-05 1.8 3.1270647321428567e-05 1.8
+ 3.127120535714286e-05 0.0 3.128236607142857e-05 0.0 3.1282924107142855e-05 1.8 3.128850446428571e-05 1.8 3.12890625e-05
+ 0.0 3.1300223214285714e-05 0.0 3.130078125e-05 1.8 3.130636160714286e-05 1.8 3.130691964285714e-05 0.0
+ 3.1318080357142856e-05 0.0 3.131863839285714e-05 1.8 3.132421875e-05 1.8 3.1324776785714284e-05 0.0 3.1335379464285715e-05
+ 0.0 3.13359375e-05 1.8 3.1342633928571426e-05 1.8 3.134319196428571e-05 0.0 3.135323660714286e-05 0.0
+ 3.135379464285714e-05 1.8 3.136049107142857e-05 1.8 3.136104910714285e-05 0.0 3.137109375e-05 0.0 3.137165178571428e-05
+ 1.8 3.137834821428571e-05 1.8 3.137890625e-05 0.0 3.138895089285714e-05 0.0 3.1389508928571425e-05 1.8
+ 3.139620535714285e-05 1.8 3.139676339285714e-05 0.0 3.1406808035714284e-05 0.0 3.140736607142857e-05 1.8
+ 3.1414062499999995e-05 1.8 3.1414620535714285e-05 0.0 3.142466517857143e-05 0.0 3.142522321428571e-05 1.8
+ 3.143191964285714e-05 1.8 3.143247767857143e-05 0.0 3.144252232142857e-05 0.0 3.144308035714285e-05 1.8
+ 3.144977678571429e-05 1.8 3.145033482142857e-05 0.0 3.146037946428571e-05 0.0 3.1460937499999995e-05 1.8
+ 3.146763392857143e-05 1.8 3.146819196428571e-05 0.0 3.1478236607142854e-05 0.0 3.1478794642857144e-05 1.8
+ 3.148549107142857e-05 1.8 3.1486049107142855e-05 0.0 3.1496093749999996e-05 0.0 3.1496651785714286e-05 1.8
+ 3.1503348214285714e-05 1.8 3.150390625e-05 0.0 3.151395089285714e-05 0.0 3.151450892857143e-05 1.8 3.1521205357142856e-05
+ 1.8 3.152176339285714e-05 0.0 3.153180803571428e-05 0.0 3.153236607142857e-05 1.8 3.15390625e-05 1.8
+ 3.153962053571428e-05 0.0 3.154966517857142e-05 0.0 3.155022321428571e-05 1.8 3.155691964285714e-05 1.8
+ 3.1557477678571424e-05 0.0 3.156752232142857e-05 0.0 3.1568080357142855e-05 1.8 3.157477678571428e-05 1.8
+ 3.1575334821428566e-05 0.0 3.1585379464285714e-05 0.0 3.15859375e-05 1.8 3.1592633928571425e-05 1.8 3.159319196428571e-05
+ 0.0 3.160323660714286e-05 0.0 3.160379464285714e-05 1.8 3.161049107142857e-05 1.8 3.161104910714286e-05
+ 0.0 3.162109375e-05 0.0 3.162165178571428e-05 1.8 3.162834821428571e-05 1.8 3.162890625e-05 0.0
+ 3.163895089285714e-05 0.0 3.1639508928571425e-05 1.8 3.164620535714285e-05 1.8 3.164676339285714e-05 0.0
+ 3.1656808035714284e-05 0.0 3.165736607142857e-05 1.8 3.1664062499999995e-05 1.8 3.1664620535714285e-05 0.0
+ 3.1674665178571426e-05 0.0 3.167522321428571e-05 1.8 3.168247767857143e-05 1.8 3.168303571428571e-05 0.0
+ 3.1691964285714285e-05 0.0 3.169252232142857e-05 1.8 3.170033482142857e-05 1.8 3.170089285714285e-05 0.0
+ 3.170982142857143e-05 0.0 3.171037946428571e-05 1.8 3.171819196428571e-05 1.8 3.1718749999999995e-05 0.0
+ 3.172767857142857e-05 0.0 3.172823660714285e-05 1.8 3.1736049107142854e-05 1.8 3.173660714285714e-05 0.0
+ 3.174553571428571e-05 0.0 3.1746093749999995e-05 1.8 3.1753906249999996e-05 1.8 3.1754464285714287e-05 0.0
+ 3.1763392857142854e-05 0.0 3.176395089285714e-05 1.8 3.177176339285714e-05 1.8 3.177232142857143e-05 0.0 3.178125e-05 0.0
+ 3.178180803571429e-05 1.8 3.178962053571428e-05 1.8 3.179017857142857e-05 0.0 3.179910714285714e-05 0.0
+ 3.179966517857143e-05 1.8 3.180747767857142e-05 1.8 3.1808035714285713e-05 0.0 3.181696428571428e-05 0.0
+ 3.181752232142857e-05 1.8 3.182533482142857e-05 1.8 3.1825892857142856e-05 0.0 3.1834821428571424e-05 0.0
+ 3.1835379464285714e-05 1.8 3.1843191964285715e-05 1.8 3.184375e-05 0.0 3.1852678571428566e-05 0.0 3.1853236607142856e-05
+ 1.8 3.186104910714286e-05 1.8 3.186160714285714e-05 0.0 3.1870535714285715e-05 0.0 3.187109375e-05 1.8
+ 3.187890625e-05 1.8 3.187946428571428e-05 0.0 3.188839285714286e-05 0.0 3.188895089285714e-05 1.8
+ 3.189676339285714e-05 1.8 3.1897321428571425e-05 0.0 3.190625e-05 0.0 3.190680803571428e-05 1.8 3.1914620535714284e-05
+ 1.8 3.191517857142857e-05 0.0 3.192410714285714e-05 0.0 3.1924665178571425e-05 1.8
+ 3.1932477678571426e-05 1.8 3.193303571428571e-05 0.0 3.1941964285714284e-05 0.0 3.194252232142857e-05 1.8
+ 3.195033482142857e-05 1.8 3.195089285714285e-05 0.0 3.195982142857143e-05 0.0 3.196037946428571e-05 1.8
+ 3.196819196428571e-05 1.8 3.1968749999999994e-05 0.0 3.197767857142857e-05 0.0 3.197823660714285e-05 1.8
+ 3.198604910714285e-05 1.8 3.1986607142857144e-05 0.0 3.199553571428571e-05 0.0 3.1996093749999995e-05 1.8 )
x1 VDD VDD vinp_I vinn_I LO_I LO_IX vout_RF LO_Q LO_QX vinp_Q vinn_Q GND tt_um_TinyWhisper_pex
**** begin user architecture code


.include /foss/designs/TinyWhisper/magic/iq_modulator/tt_um_TinyWhisper_pex.spice
.param VDD=1.8
.param Vcm=VDD/2
.param temp=27
.param Rload=10k
.param Cload=1p
.param fsig=100e3
.csparam fsig=fsig
.param flo=10.025e6
.csparam flo=flo
.param fpwm = 56e6
.csparam fpwm = fpwm
.options savecurrents method=gear reltol=1e-3 abstol=1e-15 gmin=1e-15
.control

save all

* User Constants
* Increase tstop --> more FFT bins
* Decrease tstep --> higher fs/2 in FFT
let fmin = 0.1 * flo
let fmax = 5 * flo
let tstart = 1/fsig
let tstop = 2/fsig
let tstep = 0.1/flo

* Transient Operating Point Analysis
optran 0 0 0 $&tstep $&tstart 0

* Operating Point Analysis
* op
* remzerovec
* write tt_um_TinyWhisper_pex_tb_tran.raw
* set appendwrite

* Transient Analysis
tran $&tstep $&tstop $&tstart
write tt_um_TinyWhisper_pex_tb_tran.raw

* Plotting
plot vinp_I vinn_I vinp_Q vinn_Q
plot LO_I LO_IX LO_Q LO_QX
plot vout_RF

* FFT vout_RF
setplot tran1
linearize vout_RF
set specwindow=hanning
fft vout_RF
setplot sp2

let N = length(vout_RF)
let fres = frequency[n-1]/n
let fmin_idx = ceil(const.fmin/fres)
let fmax_idx = ceil(const.fmax/fres)
let vout_RF_spec = mag(vout_RF)
let vout_RF_spec_slice = vout_RF_spec[fmin_idx,fmax_idx]
let freq = frequency[fmin_idx,fmax_idx]
meas sp vout_RF_max max vout_RF_spec_slice
let vout_RF_spec_db = 20*log10(vout_RF_spec_slice/vout_RF_max)
plot vout_RF_spec_db vs freq

* Calc HD2, HD3
* let sig_idx = ceil(const.f_sig/fres)
* let hd2_idx = 2*sig_idx
* let hd3_idx = 3*sig_idx
* let sig_pwr = iod_spec[sig_idx-1]^2+iod_spec[sig_idx]^2+iod_spec[sig_idx+1]^2
* let hd2_pwr = iod_spec[hd2_idx-1]^2+iod_spec[hd2_idx]^2+iod_spec[hd2_idx+1]^2
* let hd3_pwr = iod_spec[hd3_idx-1]^2+iod_spec[hd3_idx]^2+iod_spec[hd3_idx+1]^2
* let hd2 = sqrt(hd2_pwr/sig_pwr)
* let hd3 = sqrt(hd3_pwr/sig_pwr)
* let hd2_dB = 20*log10(hd2)
* let hd3_dB = 20*log10(hd3)
* print hd2_dB
* print hd3_dB

*quit
.endc


.lib $::SKYWATER_MODELS/sky130.lib.spice tt
**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
.end
